C {devices/lab_pin.sym} 5410 -5280 0 1 {name=p4520 lab=_1664_/A }
C {sky130_stdcells/inv_2.sym} 5370 -5280 0 0 {name=X_1591_ }
C {devices/lab_pin.sym} 5290 -5180 0 0 {name=p4521 lab=_2194_/Y }
C {devices/lab_pin.sym} 5290 -5140 0 0 {name=p4522 lab=_2210_/Y }
C {devices/lab_pin.sym} 5290 -5100 0 0 {name=p4523 lab=_2211_/Y }
C {devices/lab_pin.sym} 5450 -5140 0 1 {name=p4524 lab=_2212_/Y }
C {sky130_stdcells/o21ai_4.sym} 5370 -5140 0 0 {name=X_2212_ }
C {devices/lab_pin.sym} 5290 -5040 0 0 {name=p4525 lab=_2142_/Y }
C {devices/lab_pin.sym} 5290 -5000 0 0 {name=p4526 lab=_2138_/Y }
C {devices/lab_pin.sym} 5290 -4960 0 0 {name=p4527 lab=_2125_/A }
C {devices/lab_pin.sym} 5290 -4920 0 0 {name=p4528 lab=_1965_/B }
C {devices/lab_pin.sym} 5290 -4880 0 0 {name=p4529 lab=_2139_/X }
C {devices/lab_pin.sym} 5450 -4960 0 1 {name=p4530 lab=_2143_/Y }
C {sky130_stdcells/o32ai_4.sym} 5370 -4960 0 0 {name=X_2143_ }
C {devices/lab_pin.sym} 5290 -4820 0 0 {name=p4531 lab=_1990_/B }
C {devices/lab_pin.sym} 5290 -4780 0 0 {name=p4532 lab=_2072_/Y }
C {devices/lab_pin.sym} 5290 -4740 0 0 {name=p4533 lab=_2073_/Y }
C {devices/lab_pin.sym} 5450 -4780 0 1 {name=p4534 lab=_2075_/A }
C {sky130_stdcells/a21o_4.sym} 5370 -4780 0 0 {name=X_2074_ }
C {devices/lab_pin.sym} 5290 -4660 0 0 {name=p4535 lab=_1612_/X }
C {devices/lab_pin.sym} 5290 -4620 0 0 {name=p4536 lab=_1367_/A }
C {devices/lab_pin.sym} 5290 -4580 0 0 {name=p4537 lab=_1656_/X }
C {devices/lab_pin.sym} 5450 -4620 0 1 {name=p4538 lab=_1858_/Y }
C {sky130_stdcells/a21oi_4.sym} 5370 -4620 0 0 {name=X_1858_ }
C {devices/lab_pin.sym} 5330 -4480 0 0 {name=p4539 lab=_1927_/A }
C {devices/lab_pin.sym} 5410 -4480 0 1 {name=p4540 lab=_1927_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -4480 0 0 {name=X_1927_ }
C {devices/lab_pin.sym} 5330 -4360 0 0 {name=p4541 lab=_1189_/Y }
C {devices/lab_pin.sym} 5410 -4360 0 1 {name=p4542 lab=_1838_/A }
C {sky130_stdcells/buf_2.sym} 5370 -4360 0 0 {name=X_1789_ }
C {devices/lab_pin.sym} 5310 -4270 0 0 {name=p4543 lab=_1651_/A }
C {devices/lab_pin.sym} 5310 -4230 0 0 {name=p4544 lab=_1667_/B }
C {devices/lab_pin.sym} 5310 -4190 0 0 {name=p4545 lab=_1667_/C }
C {devices/lab_pin.sym} 5310 -4150 0 0 {name=p4546 lab=_1667_/D }
C {devices/lab_pin.sym} 5430 -4210 0 1 {name=p4547 lab=_1643_/X }
C {sky130_stdcells/and4_4.sym} 5370 -4210 0 0 {name=X_1643_ }
C {devices/lab_pin.sym} 5310 -4070 0 0 {name=p4548 lab=_1712_/A }
C {devices/lab_pin.sym} 5310 -4030 0 0 {name=p4549 lab=_1711_/X }
C {devices/lab_pin.sym} 5430 -4050 0 1 {name=p4550 lab=_1712_/Y }
C {sky130_stdcells/nand2_4.sym} 5370 -4050 0 0 {name=X_1712_ }
C {devices/lab_pin.sym} 5330 -3920 0 0 {name=p4551 lab=_2386_/Q }
C {devices/lab_pin.sym} 5410 -3920 0 1 {name=p4552 lab=_2337_/A }
C {sky130_stdcells/inv_2.sym} 5370 -3920 0 0 {name=X_1574_ }
C {devices/lab_pin.sym} 5330 -3800 0 0 {name=p4553 lab=clkbuf_3_6_0_m1_clk_local/X }
C {devices/lab_pin.sym} 5410 -3800 0 1 {name=p4554 lab=_2372_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 5370 -3800 0 0 {name=Xclkbuf_4_13_0_m1_clk_local }
C {devices/lab_pin.sym} 5310 -3700 0 0 {name=p4555 lab=_2056_/X }
C {devices/lab_pin.sym} 5310 -3660 0 0 {name=p4556 lab=_2044_/B }
C {devices/lab_pin.sym} 5310 -3620 0 0 {name=p4557 lab=_2040_/X }
C {devices/lab_pin.sym} 5430 -3660 0 1 {name=p4558 lab=_2057_/X }
C {sky130_stdcells/and3_4.sym} 5370 -3660 0 0 {name=X_2057_ }
C {sky130_stdcells/decap_3.sym} 5370 -3490 0 0 {name=XPHY_17 }
C {devices/lab_pin.sym} 5290 -3360 0 0 {name=p4559 lab=_2120_/X }
C {devices/lab_pin.sym} 5290 -3320 0 0 {name=p4560 lab=_2122_/Y }
C {devices/lab_pin.sym} 5290 -3280 0 0 {name=p4561 lab=_2125_/Y }
C {devices/lab_pin.sym} 5450 -3320 0 1 {name=p4562 lab=_2446_/D }
C {sky130_stdcells/o21ai_4.sym} 5370 -3320 0 0 {name=X_2126_ }
C {sky130_stdcells/decap_3.sym} 5370 -3150 0 0 {name=XPHY_28 }
C {sky130_stdcells/decap_3.sym} 5370 -2970 0 0 {name=XPHY_39 }
C {devices/lab_pin.sym} 5330 -2820 0 0 {name=p4563 lab=_1290_/A }
C {devices/lab_pin.sym} 5410 -2820 0 1 {name=p4564 lab=_1290_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -2820 0 0 {name=X_1290_ }
C {devices/lab_pin.sym} 5290 -2720 0 0 {name=p4565 lab=_1625_/X }
C {devices/lab_pin.sym} 5290 -2680 0 0 {name=p4566 lab=_2434_/Q }
C {devices/lab_pin.sym} 5290 -2640 0 0 {name=p4567 lab=_2448_/Q }
C {devices/lab_pin.sym} 5450 -2680 0 1 {name=p4568 lab=_1626_/Y }
C {sky130_stdcells/a21oi_4.sym} 5370 -2680 0 0 {name=X_1626_ }
C {devices/lab_pin.sym} 5310 -2560 0 0 {name=p4569 lab=_1557_/A }
C {devices/lab_pin.sym} 5310 -2520 0 0 {name=p4570 lab=_2104_/A }
C {devices/lab_pin.sym} 5310 -2480 0 0 {name=p4571 lab=_1557_/C }
C {devices/lab_pin.sym} 5430 -2520 0 1 {name=p4572 lab=_1557_/X }
C {sky130_stdcells/and3_4.sym} 5370 -2520 0 0 {name=X_1557_ }
C {devices/lab_pin.sym} 5330 -2380 0 0 {name=p4573 lab=_1435_/Y }
C {devices/lab_pin.sym} 5410 -2380 0 1 {name=p4574 lab=_1488_/X }
C {sky130_stdcells/buf_2.sym} 5370 -2380 0 0 {name=X_1488_ }
C {devices/lab_pin.sym} 5310 -2270 0 0 {name=p4575 lab=_2108_/A }
C {devices/lab_pin.sym} 5310 -2230 0 0 {name=p4576 lab=_2109_/B }
C {devices/lab_pin.sym} 5430 -2250 0 1 {name=p4577 lab=_2109_/X }
C {sky130_stdcells/and2_4.sym} 5370 -2250 0 0 {name=X_2109_ }
C {devices/lab_pin.sym} 5280 -2120 0 0 {name=p4578 lab=_2570_/CLK }
C {devices/lab_pin.sym} 5280 -2100 0 0 {name=p4579 lab=_2104_/X }
C {devices/lab_pin.sym} 5460 -2120 0 1 {name=p4580 lab=_1178_/A }
C {sky130_stdcells/dfxtp_4.sym} 5370 -2110 0 0 {name=X_2460_ }
C {devices/lab_pin.sym} 5310 -1990 0 0 {name=p4581 lab=_2615_/Q }
C {devices/lab_pin.sym} 5310 -1950 0 0 {name=p4582 lab=_1411_/B }
C {devices/lab_pin.sym} 5430 -1970 0 1 {name=p4583 lab=_1411_/X }
C {sky130_stdcells/or2_4.sym} 5370 -1970 0 0 {name=X_1411_ }
C {devices/lab_pin.sym} 5290 -1880 0 0 {name=p4584 lab=_1335_/D }
C {devices/lab_pin.sym} 5290 -1840 0 0 {name=p4585 lab=_1324_/X }
C {devices/lab_pin.sym} 5290 -1800 0 0 {name=p4586 lab=_1329_/X }
C {devices/lab_pin.sym} 5290 -1760 0 0 {name=p4587 lab=_1321_/X }
C {devices/lab_pin.sym} 5290 -1730 0 0 {name=p4588 lab=_1339_/X }
C {devices/lab_pin.sym} 5450 -1800 0 1 {name=p4589 lab=_1342_/Y }
C {sky130_stdcells/a41oi_4.sym} 5370 -1800 0 0 {name=X_1342_ }
C {devices/lab_pin.sym} 5280 -1640 0 0 {name=p4590 lab=_2570_/CLK }
C {devices/lab_pin.sym} 5280 -1620 0 0 {name=p4591 lab=_2391_/D }
C {devices/lab_pin.sym} 5460 -1640 0 1 {name=p4592 lab=_1689_/A }
C {sky130_stdcells/dfxtp_4.sym} 5370 -1630 0 0 {name=X_2391_ }
C {devices/lab_pin.sym} 5330 -1500 0 0 {name=p4593 lab=_1277_/A }
C {devices/lab_pin.sym} 5410 -1500 0 1 {name=p4594 lab=_1854_/A }
C {sky130_stdcells/inv_2.sym} 5370 -1500 0 0 {name=X_1273_ }
C {devices/lab_pin.sym} 5310 -1410 0 0 {name=p4595 lab=_1651_/A }
C {devices/lab_pin.sym} 5310 -1370 0 0 {name=p4596 lab=_1609_/B }
C {devices/lab_pin.sym} 5310 -1330 0 0 {name=p4597 lab=_1667_/C }
C {devices/lab_pin.sym} 5310 -1290 0 0 {name=p4598 lab=_1667_/D }
C {devices/lab_pin.sym} 5430 -1350 0 1 {name=p4599 lab=_1609_/X }
C {sky130_stdcells/and4_4.sym} 5370 -1350 0 0 {name=X_1609_ }
C {devices/lab_pin.sym} 5280 -1200 0 0 {name=p4600 lab=_2390_/CLK }
C {devices/lab_pin.sym} 5280 -1180 0 0 {name=p4601 lab=_1782_/Y }
C {devices/lab_pin.sym} 5460 -1200 0 1 {name=p4602 lab=_1780_/B }
C {sky130_stdcells/dfxtp_4.sym} 5370 -1190 0 0 {name=X_2589_ }
C {devices/lab_pin.sym} 5310 -1070 0 0 {name=p4603 lab=_1891_/A }
C {devices/lab_pin.sym} 5310 -1030 0 0 {name=p4604 lab=DATA_AVAILABLE[3] }
C {devices/lab_pin.sym} 5430 -1050 0 1 {name=p4605 lab=_2550_/D }
C {sky130_stdcells/and2_4.sym} 5370 -1050 0 0 {name=X_1891_ }
C {devices/lab_pin.sym} 5330 -920 0 0 {name=p4606 lab=_1960_/A }
C {devices/lab_pin.sym} 5410 -920 0 1 {name=p4607 lab=_1960_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -920 0 0 {name=X_1960_ }
C {devices/lab_pin.sym} 5280 -800 0 0 {name=p4608 lab=_2445_/CLK }
C {devices/lab_pin.sym} 5280 -780 0 0 {name=p4609 lab=_2135_/Y }
C {devices/lab_pin.sym} 5460 -800 0 1 {name=p4610 lab=_2134_/C }
C {sky130_stdcells/dfxtp_4.sym} 5370 -790 0 0 {name=X_2443_ }
C {devices/lab_pin.sym} 10860 -21880 0 0 {name=p4611 lab=_2513_/CLK }
C {devices/lab_pin.sym} 10860 -21860 0 0 {name=p4612 lab=_1953_/X }
C {devices/lab_pin.sym} 11040 -21880 0 1 {name=p4613 lab=DATA_TO_HASH[5] }
C {sky130_stdcells/dfxtp_4.sym} 10950 -21870 0 0 {name=X_2512_ }
C {devices/lab_pin.sym} 10860 -21740 0 0 {name=p4614 lab=_2496_/CLK }
C {devices/lab_pin.sym} 10860 -21720 0 0 {name=p4615 lab=_2373_/Q }
C {devices/lab_pin.sym} 11040 -21740 0 1 {name=p4616 lab=_2375_/D }
C {sky130_stdcells/dfxtp_4.sym} 10950 -21730 0 0 {name=X_2374_ }
C {devices/lab_pin.sym} 10870 -21640 0 0 {name=p4617 lab=_1316_/B }
C {devices/lab_pin.sym} 10870 -21600 0 0 {name=p4618 lab=_1324_/X }
C {devices/lab_pin.sym} 10870 -21560 0 0 {name=p4619 lab=_1321_/X }
C {devices/lab_pin.sym} 10870 -21520 0 0 {name=p4620 lab=_1316_/D }
C {devices/lab_pin.sym} 10870 -21490 0 0 {name=p4621 lab=_1274_/X }
C {devices/lab_pin.sym} 11030 -21560 0 1 {name=p4622 lab=_1325_/Y }
C {sky130_stdcells/a41oi_4.sym} 10950 -21560 0 0 {name=X_1325_ }
C {devices/lab_pin.sym} 10910 -21400 0 0 {name=p4623 lab=_1277_/D }
C {devices/lab_pin.sym} 10990 -21400 0 1 {name=p4624 lab=_1256_/Y }
C {sky130_stdcells/inv_2.sym} 10950 -21400 0 0 {name=X_1256_ }
C {devices/lab_pin.sym} 10910 -21280 0 0 {name=p4625 lab=_1187_/A }
C {devices/lab_pin.sym} 10990 -21280 0 1 {name=p4626 lab=_1187_/X }
C {sky130_stdcells/buf_2.sym} 10950 -21280 0 0 {name=X_1187_ }
C {devices/lab_pin.sym} 10860 -21160 0 0 {name=p4627 lab=DATA_FROM_HASH[5] }
C {sky130_stdcells/diode_2.sym} 10950 -21160 0 0 {name=XINSDIODE2_1 }
C {devices/lab_pin.sym} 10910 -21040 0 0 {name=p4628 lab=clkbuf_4_9_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 10990 -21040 0 1 {name=p4629 lab=_2606_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10950 -21040 0 0 {name=Xclkbuf_4_8_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 10890 -20930 0 0 {name=p4630 lab=_1284_/X }
C {devices/lab_pin.sym} 10890 -20890 0 0 {name=p4631 lab=_2089_/Y }
C {devices/lab_pin.sym} 11010 -20910 0 1 {name=p4632 lab=_2090_/Y }
C {sky130_stdcells/nor2_4.sym} 10950 -20910 0 0 {name=X_2090_ }
C {devices/lab_pin.sym} 10910 -20780 0 0 {name=p4633 lab=_1874_/A }
C {devices/lab_pin.sym} 10990 -20780 0 1 {name=p4634 lab=_1878_/A }
C {sky130_stdcells/buf_2.sym} 10950 -20780 0 0 {name=X_1874_ }
C {devices/lab_pin.sym} 10910 -20660 0 0 {name=p4635 lab=_1339_/X }
C {devices/lab_pin.sym} 10990 -20660 0 1 {name=p4636 lab=_1947_/A }
C {sky130_stdcells/buf_2.sym} 10950 -20660 0 0 {name=X_1943_ }
C {devices/lab_pin.sym} 10860 -20540 0 0 {name=p4637 lab=_2428_/CLK }
C {devices/lab_pin.sym} 10860 -20520 0 0 {name=p4638 lab=_2426_/D }
C {devices/lab_pin.sym} 11040 -20540 0 1 {name=p4639 lab=_2426_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10950 -20530 0 0 {name=X_2426_ }
C {devices/lab_pin.sym} 10890 -20410 0 0 {name=p4640 lab=_1228_/Y }
C {devices/lab_pin.sym} 10890 -20370 0 0 {name=p4641 lab=_1238_/Y }
C {devices/lab_pin.sym} 11010 -20390 0 1 {name=p4642 lab=_1239_/Y }
C {sky130_stdcells/nor2_4.sym} 10950 -20390 0 0 {name=X_1239_ }
C {devices/lab_pin.sym} 10890 -20280 0 0 {name=p4643 lab=_1308_/A }
C {devices/lab_pin.sym} 10890 -20240 0 0 {name=p4644 lab=_2636_/Q }
C {devices/lab_pin.sym} 10890 -20200 0 0 {name=p4645 lab=_1308_/C }
C {devices/lab_pin.sym} 11010 -20240 0 1 {name=p4646 lab=_1308_/Y }
C {sky130_stdcells/nand3_4.sym} 10950 -20240 0 0 {name=X_1308_ }
C {devices/lab_pin.sym} 10870 -20140 0 0 {name=p4647 lab=_1581_/X }
C {devices/lab_pin.sym} 10870 -20100 0 0 {name=p4648 lab=_2260_/Y }
C {devices/lab_pin.sym} 10870 -20060 0 0 {name=p4649 lab=_2278_/A }
C {devices/lab_pin.sym} 10870 -20020 0 0 {name=p4650 lab=_1929_/Y }
C {devices/lab_pin.sym} 10870 -19980 0 0 {name=p4651 lab=_2279_/X }
C {devices/lab_pin.sym} 11030 -20060 0 1 {name=p4652 lab=_2411_/D }
C {sky130_stdcells/o32ai_4.sym} 10950 -20060 0 0 {name=X_2288_ }
C {devices/lab_pin.sym} 11010 -19910 0 1 {name=p4653 lab=one }
C {devices/lab_pin.sym} 11010 -19870 0 1 {name=p4654 lab=_2357_/LO }
C {sky130_stdcells/conb_1.sym} 10950 -19890 0 0 {name=X_2357_ }
C {devices/lab_pin.sym} 10890 -19770 0 0 {name=p4655 lab=_1428_/D }
C {devices/lab_pin.sym} 10890 -19730 0 0 {name=p4656 lab=_1590_/B }
C {devices/lab_pin.sym} 11010 -19750 0 1 {name=p4657 lab=_1613_/A }
C {sky130_stdcells/nor2_4.sym} 10950 -19750 0 0 {name=X_1590_ }
C {devices/lab_pin.sym} 10870 -19640 0 0 {name=p4658 lab=_1990_/B }
C {devices/lab_pin.sym} 10870 -19600 0 0 {name=p4659 lab=_2072_/Y }
C {devices/lab_pin.sym} 10870 -19560 0 0 {name=p4660 lab=_1374_/X }
C {devices/lab_pin.sym} 11030 -19600 0 1 {name=p4661 lab=_2073_/Y }
C {sky130_stdcells/o21ai_4.sym} 10950 -19600 0 0 {name=X_2073_ }
C {devices/lab_pin.sym} 10890 -19470 0 0 {name=p4662 lab=_2146_/A }
C {devices/lab_pin.sym} 10890 -19430 0 0 {name=p4663 lab=THREAD_COUNT[1] }
C {devices/lab_pin.sym} 11010 -19450 0 1 {name=p4664 lab=_2211_/Y }
C {sky130_stdcells/nand2_4.sym} 10950 -19450 0 0 {name=X_2211_ }
C {devices/lab_pin.sym} 10910 -19320 0 0 {name=p4665 lab=_1514_/A }
C {devices/lab_pin.sym} 10990 -19320 0 1 {name=p4666 lab=_2142_/Y }
C {sky130_stdcells/inv_2.sym} 10950 -19320 0 0 {name=X_2142_ }
C {devices/lab_pin.sym} 10870 -19220 0 0 {name=p4667 lab=_1855_/Y }
C {devices/lab_pin.sym} 10870 -19180 0 0 {name=p4668 lab=_1646_/X }
C {devices/lab_pin.sym} 10870 -19140 0 0 {name=p4669 lab=_1856_/X }
C {devices/lab_pin.sym} 11030 -19180 0 1 {name=p4670 lab=_1857_/Y }
C {sky130_stdcells/a21oi_4.sym} 10950 -19180 0 0 {name=X_1857_ }
C {devices/lab_pin.sym} 10910 -19040 0 0 {name=p4671 lab=_2591_/Q }
C {devices/lab_pin.sym} 10990 -19040 0 1 {name=p4672 lab=_1788_/X }
C {sky130_stdcells/buf_2.sym} 10950 -19040 0 0 {name=X_1788_ }
C {devices/lab_pin.sym} 10890 -18930 0 0 {name=p4673 lab=_1930_/A }
C {devices/lab_pin.sym} 10890 -18890 0 0 {name=p4674 lab=_1925_/Y }
C {devices/lab_pin.sym} 11010 -18910 0 1 {name=p4675 lab=_2529_/D }
C {sky130_stdcells/nor2_4.sym} 10950 -18910 0 0 {name=X_1926_ }
C {devices/lab_pin.sym} 10860 -18780 0 0 {name=p4676 lab=_2408_/CLK }
C {devices/lab_pin.sym} 10860 -18760 0 0 {name=p4677 lab=_2296_/Y }
C {devices/lab_pin.sym} 11040 -18780 0 1 {name=p4678 lab=_2295_/C }
C {sky130_stdcells/dfxtp_4.sym} 10950 -18770 0 0 {name=X_2409_ }
C {devices/lab_pin.sym} 10870 -18660 0 0 {name=p4679 lab=_1615_/Y }
C {devices/lab_pin.sym} 10870 -18620 0 0 {name=p4680 lab=_1639_/Y }
C {devices/lab_pin.sym} 10870 -18580 0 0 {name=p4681 lab=_1641_/X }
C {devices/lab_pin.sym} 11030 -18620 0 1 {name=p4682 lab=_1642_/Y }
C {sky130_stdcells/o21ai_4.sym} 10950 -18620 0 0 {name=X_1642_ }
C {devices/lab_pin.sym} 10870 -18510 0 0 {name=p4683 lab=_1937_/A }
C {devices/lab_pin.sym} 10870 -18470 0 0 {name=p4684 lab=_2181_/A }
C {devices/lab_pin.sym} 10870 -18430 0 0 {name=p4685 lab=_1708_/X }
C {devices/lab_pin.sym} 10870 -18390 0 0 {name=p4686 lab=_1710_/Y }
C {devices/lab_pin.sym} 11030 -18450 0 1 {name=p4687 lab=_1711_/X }
C {sky130_stdcells/a211o_4.sym} 10950 -18450 0 0 {name=X_1711_ }
C {devices/lab_pin.sym} 10870 -18320 0 0 {name=p4688 lab=_1564_/X }
C {devices/lab_pin.sym} 10870 -18280 0 0 {name=p4689 lab=_1572_/Y }
C {devices/lab_pin.sym} 10870 -18240 0 0 {name=p4690 lab=_1454_/X }
C {devices/lab_pin.sym} 11030 -18280 0 1 {name=p4691 lab=_2600_/D }
C {sky130_stdcells/a21oi_4.sym} 10950 -18280 0 0 {name=X_1573_ }
C {devices/lab_pin.sym} 10870 -18180 0 0 {name=p4692 lab=_2053_/Y }
C {devices/lab_pin.sym} 10870 -18140 0 0 {name=p4693 lab=_2062_/B }
C {devices/lab_pin.sym} 10870 -18100 0 0 {name=p4694 lab=_2055_/X }
C {devices/lab_pin.sym} 10870 -18060 0 0 {name=p4695 lab=_1993_/C }
C {devices/lab_pin.sym} 10870 -18030 0 0 {name=p4696 lab=_1993_/D }
C {devices/lab_pin.sym} 11030 -18100 0 1 {name=p4697 lab=_2056_/X }
C {sky130_stdcells/a41o_4.sym} 10950 -18100 0 0 {name=X_2056_ }
C {sky130_stdcells/decap_3.sym} 10950 -17910 0 0 {name=XPHY_18 }
C {devices/lab_pin.sym} 10890 -17780 0 0 {name=p4698 lab=_2125_/A }
C {devices/lab_pin.sym} 10890 -17740 0 0 {name=p4699 lab=_2335_/A }
C {devices/lab_pin.sym} 10890 -17700 0 0 {name=p4700 lab=_2125_/C }
C {devices/lab_pin.sym} 11010 -17740 0 1 {name=p4701 lab=_2125_/Y }
C {sky130_stdcells/nand3_4.sym} 10950 -17740 0 0 {name=X_2125_ }
C {sky130_stdcells/decap_3.sym} 10950 -17570 0 0 {name=XPHY_29 }
C {devices/lab_pin.sym} 10890 -17430 0 0 {name=p4702 lab=_1901_/X }
C {devices/lab_pin.sym} 10890 -17390 0 0 {name=p4703 lab=_1908_/Y }
C {devices/lab_pin.sym} 11010 -17410 0 1 {name=p4704 lab=_2539_/D }
C {sky130_stdcells/nor2_4.sym} 10950 -17410 0 0 {name=X_1909_ }
C {devices/lab_pin.sym} 10890 -17290 0 0 {name=p4705 lab=_1556_/A }
C {devices/lab_pin.sym} 10890 -17250 0 0 {name=p4706 lab=_1537_/X }
C {devices/lab_pin.sym} 11010 -17270 0 1 {name=p4707 lab=_1557_/C }
C {sky130_stdcells/nand2_4.sym} 10950 -17270 0 0 {name=X_1556_ }
C {devices/lab_pin.sym} 10910 -17140 0 0 {name=p4708 lab=_1623_/Y }
C {devices/lab_pin.sym} 10990 -17140 0 1 {name=p4709 lab=_1625_/X }
C {sky130_stdcells/buf_2.sym} 10950 -17140 0 0 {name=X_1625_ }
C {devices/lab_pin.sym} 10890 -17050 0 0 {name=p4710 lab=_1487_/A }
C {devices/lab_pin.sym} 10890 -17010 0 0 {name=p4711 lab=_1505_/B }
C {devices/lab_pin.sym} 10890 -16970 0 0 {name=p4712 lab=_1494_/B }
C {devices/lab_pin.sym} 10890 -16930 0 0 {name=p4713 lab=_1505_/C }
C {devices/lab_pin.sym} 11010 -16990 0 1 {name=p4714 lab=_1487_/Y }
C {sky130_stdcells/nand4_4.sym} 10950 -16990 0 0 {name=X_1487_ }
C {devices/lab_pin.sym} 10890 -16850 0 0 {name=p4715 lab=_2108_/A }
C {devices/lab_pin.sym} 10890 -16810 0 0 {name=p4716 lab=SCLK_fromHost }
C {devices/lab_pin.sym} 11010 -16830 0 1 {name=p4717 lab=_2456_/D }
C {sky130_stdcells/and2_4.sym} 10950 -16830 0 0 {name=X_2108_ }
C {devices/lab_pin.sym} 10910 -16700 0 0 {name=p4718 lab=_2039_/A }
C {devices/lab_pin.sym} 10990 -16700 0 1 {name=p4719 lab=_2486_/D }
C {sky130_stdcells/inv_2.sym} 10950 -16700 0 0 {name=X_2039_ }
C {devices/lab_pin.sym} 10910 -16580 0 0 {name=p4720 lab=_1409_/Y }
C {devices/lab_pin.sym} 10990 -16580 0 1 {name=p4721 lab=_1411_/B }
C {sky130_stdcells/inv_2.sym} 10950 -16580 0 0 {name=X_1410_ }
C {devices/lab_pin.sym} 10870 -16480 0 0 {name=p4722 lab=_1335_/C }
C {devices/lab_pin.sym} 10870 -16440 0 0 {name=p4723 lab=_1338_/X }
C {devices/lab_pin.sym} 10870 -16400 0 0 {name=p4724 lab=_1340_/Y }
C {devices/lab_pin.sym} 11030 -16440 0 1 {name=p4725 lab=_1341_/X }
C {sky130_stdcells/o21a_4.sym} 10950 -16440 0 0 {name=X_1341_ }
C {devices/lab_pin.sym} 10860 -16300 0 0 {name=p4726 lab=_2390_/CLK }
C {devices/lab_pin.sym} 10860 -16280 0 0 {name=p4727 lab=_2390_/D }
C {devices/lab_pin.sym} 11040 -16300 0 1 {name=p4728 lab=_2390_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10950 -16290 0 0 {name=X_2390_ }
C {devices/lab_pin.sym} 10890 -16190 0 0 {name=p4729 lab=_2641_/Q }
C {devices/lab_pin.sym} 10890 -16150 0 0 {name=p4730 lab=_1265_/Y }
C {devices/lab_pin.sym} 10890 -16110 0 0 {name=p4731 lab=_1277_/D }
C {devices/lab_pin.sym} 10890 -16070 0 0 {name=p4732 lab=_1224_/A }
C {devices/lab_pin.sym} 11010 -16130 0 1 {name=p4733 lab=_1282_/C }
C {sky130_stdcells/nand4_4.sym} 10950 -16130 0 0 {name=X_1272_ }
C {devices/lab_pin.sym} 10890 -15990 0 0 {name=p4734 lab=_2602_/Q }
C {devices/lab_pin.sym} 10890 -15950 0 0 {name=p4735 lab=_1608_/B }
C {devices/lab_pin.sym} 11010 -15970 0 1 {name=p4736 lab=_1667_/D }
C {sky130_stdcells/nor2_4.sym} 10950 -15970 0 0 {name=X_1608_ }
C {devices/lab_pin.sym} 10860 -15840 0 0 {name=p4737 lab=_2390_/CLK }
C {devices/lab_pin.sym} 10860 -15820 0 0 {name=p4738 lab=_2588_/D }
C {devices/lab_pin.sym} 11040 -15840 0 1 {name=p4739 lab=_2349_/A }
C {sky130_stdcells/dfxtp_4.sym} 10950 -15830 0 0 {name=X_2588_ }
C {devices/lab_pin.sym} 10870 -15720 0 0 {name=p4740 lab=_1466_/A }
C {devices/lab_pin.sym} 10870 -15680 0 0 {name=p4741 lab=_1482_/Y }
C {devices/lab_pin.sym} 10870 -15640 0 0 {name=p4742 lab=_1538_/X }
C {devices/lab_pin.sym} 11030 -15680 0 1 {name=p4743 lab=_1539_/Y }
C {sky130_stdcells/o21ai_4.sym} 10950 -15680 0 0 {name=X_1539_ }
C {devices/lab_pin.sym} 10910 -15540 0 0 {name=p4744 lab=clkbuf_4_1_0_m1_clk_local/A }
C {devices/lab_pin.sym} 10990 -15540 0 1 {name=p4745 lab=_2638_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10950 -15540 0 0 {name=Xclkbuf_4_1_0_m1_clk_local }
C {devices/lab_pin.sym} 10890 -15430 0 0 {name=p4746 lab=_1891_/A }
C {devices/lab_pin.sym} 10890 -15390 0 0 {name=p4747 lab=_2559_/Q }
C {devices/lab_pin.sym} 11010 -15410 0 1 {name=p4748 lab=_2551_/D }
C {sky130_stdcells/and2_4.sym} 10950 -15410 0 0 {name=X_1890_ }
C {devices/lab_pin.sym} 10860 -15280 0 0 {name=p4749 lab=_2496_/CLK }
C {devices/lab_pin.sym} 10860 -15260 0 0 {name=p4750 lab=_2373_/D }
C {devices/lab_pin.sym} 11040 -15280 0 1 {name=p4751 lab=_2373_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10950 -15270 0 0 {name=X_2373_ }
C {devices/lab_pin.sym} 10860 -15140 0 0 {name=p4752 lab=_2483_/CLK }
C {devices/lab_pin.sym} 10860 -15120 0 0 {name=p4753 lab=_1954_/X }
C {devices/lab_pin.sym} 11040 -15140 0 1 {name=p4754 lab=DATA_TO_HASH[4] }
C {sky130_stdcells/dfxtp_4.sym} 10950 -15130 0 0 {name=X_2511_ }
C {devices/lab_pin.sym} 10860 -15000 0 0 {name=p4755 lab=_2598_/CLK }
C {devices/lab_pin.sym} 10860 -14980 0 0 {name=p4756 lab=_2442_/D }
C {devices/lab_pin.sym} 11040 -15000 0 1 {name=p4757 lab=_1960_/A }
C {sky130_stdcells/dfxtp_4.sym} 10950 -14990 0 0 {name=X_2442_ }
C {devices/lab_pin.sym} 10910 -14860 0 0 {name=p4758 lab=clkbuf_3_6_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 10990 -14860 0 1 {name=p4759 lab=_2550_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10950 -14860 0 0 {name=Xclkbuf_4_13_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 10910 -14740 0 0 {name=p4760 lab=_1239_/Y }
C {devices/lab_pin.sym} 10990 -14740 0 1 {name=p4761 lab=_1324_/X }
C {sky130_stdcells/buf_2.sym} 10950 -14740 0 0 {name=X_1324_ }
C {devices/lab_pin.sym} 10910 -14620 0 0 {name=p4762 lab=_1188_/A }
C {devices/lab_pin.sym} 10990 -14620 0 1 {name=p4763 lab=_1187_/A }
C {sky130_stdcells/buf_2.sym} 10950 -14620 0 0 {name=X_1186_ }
C {devices/lab_pin.sym} 10910 -14500 0 0 {name=p4764 lab=_1254_/X }
C {devices/lab_pin.sym} 10990 -14500 0 1 {name=p4765 lab=_1971_/A }
C {sky130_stdcells/buf_2.sym} 10950 -14500 0 0 {name=X_1255_ }
C {devices/lab_pin.sym} 10860 -14380 0 0 {name=p4766 lab=SCLK_fromHost }
C {sky130_stdcells/diode_2.sym} 10950 -14380 0 0 {name=XINSDIODE2_2 }
C {devices/lab_pin.sym} 10910 -14260 0 0 {name=p4767 lab=clkbuf_3_7_0_m1_clk_local/A }
C {devices/lab_pin.sym} 10990 -14260 0 1 {name=p4768 lab=clkbuf_3_7_0_m1_clk_local/X }
C {sky130_stdcells/clkbuf_1.sym} 10950 -14260 0 0 {name=Xclkbuf_3_7_0_m1_clk_local }
C {devices/lab_pin.sym} 10890 -14150 0 0 {name=p4769 lab=_1938_/A }
C {devices/lab_pin.sym} 10890 -14110 0 0 {name=p4770 lab=_1942_/B }
C {devices/lab_pin.sym} 11010 -14130 0 1 {name=p4771 lab=_2518_/D }
C {sky130_stdcells/nor2_4.sym} 10950 -14130 0 0 {name=X_1942_ }
C {devices/lab_pin.sym} 10910 -14000 0 0 {name=p4772 lab=_1838_/A }
C {devices/lab_pin.sym} 10990 -14000 0 1 {name=p4773 lab=_1874_/A }
C {sky130_stdcells/buf_2.sym} 10950 -14000 0 0 {name=X_1873_ }
C {devices/lab_pin.sym} 10870 -13900 0 0 {name=p4774 lab=_2354_/Y }
C {devices/lab_pin.sym} 10870 -13860 0 0 {name=p4775 lab=_2322_/A }
C {devices/lab_pin.sym} 10870 -13820 0 0 {name=p4776 lab=_2355_/Y }
C {devices/lab_pin.sym} 11030 -13860 0 1 {name=p4777 lab=_2652_/D }
C {sky130_stdcells/a21oi_4.sym} 10950 -13860 0 0 {name=X_2356_ }
C {devices/lab_pin.sym} 10860 -13720 0 0 {name=p4778 lab=_2408_/CLK }
C {devices/lab_pin.sym} 10860 -13700 0 0 {name=p4779 lab=_2425_/D }
C {devices/lab_pin.sym} 11040 -13720 0 1 {name=p4780 lab=_1937_/A }
C {sky130_stdcells/dfxtp_4.sym} 10950 -13710 0 0 {name=X_2425_ }
C {devices/lab_pin.sym} 10890 -13610 0 0 {name=p4781 lab=_2620_/Q }
C {devices/lab_pin.sym} 10890 -13570 0 0 {name=p4782 lab=_1379_/A }
C {devices/lab_pin.sym} 10890 -13530 0 0 {name=p4783 lab=_1365_/D }
C {devices/lab_pin.sym} 10890 -13490 0 0 {name=p4784 lab=_1238_/D }
C {devices/lab_pin.sym} 11010 -13550 0 1 {name=p4785 lab=_1238_/Y }
C {sky130_stdcells/nand4_4.sym} 10950 -13550 0 0 {name=X_1238_ }
C {devices/lab_pin.sym} 10870 -13420 0 0 {name=p4786 lab=_2636_/Q }
C {devices/lab_pin.sym} 10870 -13380 0 0 {name=p4787 lab=_1305_/X }
C {devices/lab_pin.sym} 10870 -13340 0 0 {name=p4788 lab=_1306_/X }
C {devices/lab_pin.sym} 11030 -13380 0 1 {name=p4789 lab=_1307_/X }
C {sky130_stdcells/o21a_4.sym} 10950 -13380 0 0 {name=X_1307_ }
C {devices/lab_pin.sym} 10870 -13280 0 0 {name=p4790 lab=_1581_/X }
C {devices/lab_pin.sym} 10870 -13240 0 0 {name=p4791 lab=_2257_/Y }
C {devices/lab_pin.sym} 10870 -13200 0 0 {name=p4792 lab=_2278_/A }
C {devices/lab_pin.sym} 10870 -13160 0 0 {name=p4793 lab=_1927_/Y }
C {devices/lab_pin.sym} 10870 -13120 0 0 {name=p4794 lab=_2279_/X }
C {devices/lab_pin.sym} 11030 -13200 0 1 {name=p4795 lab=_2412_/D }
C {sky130_stdcells/o32ai_4.sym} 10950 -13200 0 0 {name=X_2287_ }
C {devices/lab_pin.sym} 10870 -13060 0 0 {name=p4796 lab=_2207_/Y }
C {devices/lab_pin.sym} 10870 -13020 0 0 {name=p4797 lab=_2208_/X }
C {devices/lab_pin.sym} 10870 -12980 0 0 {name=p4798 lab=_2209_/X }
C {devices/lab_pin.sym} 11030 -13020 0 1 {name=p4799 lab=_2210_/Y }
C {sky130_stdcells/a21oi_4.sym} 10950 -13020 0 0 {name=X_2210_ }
C {devices/lab_pin.sym} 10890 -12890 0 0 {name=p4800 lab=_2071_/Y }
C {devices/lab_pin.sym} 10890 -12850 0 0 {name=p4801 lab=_2060_/B }
C {devices/lab_pin.sym} 11010 -12870 0 1 {name=p4802 lab=_2072_/Y }
C {sky130_stdcells/nor2_4.sym} 10950 -12870 0 0 {name=X_2072_ }
C {devices/lab_pin.sym} 10870 -12780 0 0 {name=p4803 lab=_1503_/Y }
C {devices/lab_pin.sym} 10870 -12740 0 0 {name=p4804 lab=_2138_/Y }
C {devices/lab_pin.sym} 10870 -12700 0 0 {name=p4805 lab=_2125_/A }
C {devices/lab_pin.sym} 10870 -12660 0 0 {name=p4806 lab=_1963_/B }
C {devices/lab_pin.sym} 10870 -12620 0 0 {name=p4807 lab=_2139_/X }
C {devices/lab_pin.sym} 11030 -12700 0 1 {name=p4808 lab=_2441_/D }
C {sky130_stdcells/o32ai_4.sym} 10950 -12700 0 0 {name=X_2141_ }
C {devices/lab_pin.sym} 10910 -12540 0 0 {name=p4809 lab=_2174_/B }
C {devices/lab_pin.sym} 10990 -12540 0 1 {name=p4810 lab=_1925_/Y }
C {sky130_stdcells/inv_2.sym} 10950 -12540 0 0 {name=X_1925_ }
C {devices/lab_pin.sym} 10890 -12440 0 0 {name=p4811 lab=_1856_/A }
C {devices/lab_pin.sym} 10890 -12400 0 0 {name=p4812 lab=_1318_/A }
C {devices/lab_pin.sym} 10890 -12360 0 0 {name=p4813 lab=_1651_/X }
C {devices/lab_pin.sym} 11010 -12400 0 1 {name=p4814 lab=_1856_/X }
C {sky130_stdcells/and3_4.sym} 10950 -12400 0 0 {name=X_1856_ }
C {devices/lab_pin.sym} 10910 -12260 0 0 {name=p4815 lab=_1786_/Y }
C {devices/lab_pin.sym} 10990 -12260 0 1 {name=p4816 lab=_1983_/B }
C {sky130_stdcells/buf_2.sym} 10950 -12260 0 0 {name=X_1787_ }
C {devices/lab_pin.sym} 10870 -12170 0 0 {name=p4817 lab=_1840_/C }
C {devices/lab_pin.sym} 10870 -12130 0 0 {name=p4818 lab=_2385_/Q }
C {devices/lab_pin.sym} 10870 -12090 0 0 {name=p4819 lab=_2102_/A }
C {devices/lab_pin.sym} 10870 -12050 0 0 {name=p4820 lab=_2338_/X }
C {devices/lab_pin.sym} 11030 -12110 0 1 {name=p4821 lab=_2385_/D }
C {sky130_stdcells/a211o_4.sym} 10950 -12110 0 0 {name=X_2339_ }
C {devices/lab_pin.sym} 10860 -11960 0 0 {name=p4822 lab=_2408_/CLK }
C {devices/lab_pin.sym} 10860 -11940 0 0 {name=p4823 lab=_2299_/Y }
C {devices/lab_pin.sym} 11040 -11960 0 1 {name=p4824 lab=ID_toHost }
C {sky130_stdcells/dfxtp_4.sym} 10950 -11950 0 0 {name=X_2408_ }
C {devices/lab_pin.sym} 10870 -11840 0 0 {name=p4825 lab=_1569_/X }
C {devices/lab_pin.sym} 10870 -11800 0 0 {name=p4826 lab=_1556_/A }
C {devices/lab_pin.sym} 10870 -11760 0 0 {name=p4827 lab=_1860_/B }
C {devices/lab_pin.sym} 11030 -11800 0 1 {name=p4828 lab=_1572_/Y }
C {sky130_stdcells/o21ai_4.sym} 10950 -11800 0 0 {name=X_1572_ }
C {devices/lab_pin.sym} 10890 -11670 0 0 {name=p4829 lab=_1251_/Y }
C {devices/lab_pin.sym} 10890 -11630 0 0 {name=p4830 lab=_1640_/X }
C {devices/lab_pin.sym} 11010 -11650 0 1 {name=p4831 lab=_1641_/X }
C {sky130_stdcells/or2_4.sym} 10950 -11650 0 0 {name=X_1641_ }
C {devices/lab_pin.sym} 10890 -11530 0 0 {name=p4832 lab=_1630_/X }
C {devices/lab_pin.sym} 10890 -11490 0 0 {name=p4833 lab=_1710_/B }
C {devices/lab_pin.sym} 11010 -11510 0 1 {name=p4834 lab=_1710_/Y }
C {sky130_stdcells/nor2_4.sym} 10950 -11510 0 0 {name=X_1710_ }
C {devices/lab_pin.sym} 10910 -11380 0 0 {name=p4835 lab=_1555_/A }
C {devices/lab_pin.sym} 10990 -11380 0 1 {name=p4836 lab=_2335_/A }
C {sky130_stdcells/buf_2.sym} 10950 -11380 0 0 {name=X_2124_ }
C {devices/lab_pin.sym} 10910 -11260 0 0 {name=p4837 lab=_1993_/A }
C {devices/lab_pin.sym} 10990 -11260 0 1 {name=p4838 lab=_2055_/X }
C {sky130_stdcells/buf_2.sym} 10950 -11260 0 0 {name=X_2055_ }
C {sky130_stdcells/decap_3.sym} 10950 -11110 0 0 {name=XPHY_19 }
C {devices/lab_pin.sym} 10910 -10960 0 0 {name=p4839 lab=_2463_/Q }
C {devices/lab_pin.sym} 10990 -10960 0 1 {name=p4840 lab=_1840_/C }
C {sky130_stdcells/inv_2.sym} 10950 -10960 0 0 {name=X_1839_ }
C {devices/lab_pin.sym} 10910 -10840 0 0 {name=p4841 lab=_2177_/B }
C {devices/lab_pin.sym} 10990 -10840 0 1 {name=p4842 lab=_1908_/Y }
C {sky130_stdcells/inv_2.sym} 10950 -10840 0 0 {name=X_1908_ }
C {devices/lab_pin.sym} 10910 -10720 0 0 {name=p4843 lab=_1623_/Y }
C {devices/lab_pin.sym} 10990 -10720 0 1 {name=p4844 lab=_1624_/X }
C {sky130_stdcells/buf_2.sym} 10950 -10720 0 0 {name=X_1624_ }
C {devices/lab_pin.sym} 10910 -10600 0 0 {name=p4845 lab=_1555_/A }
C {devices/lab_pin.sym} 10990 -10600 0 1 {name=p4846 lab=_2104_/A }
C {sky130_stdcells/buf_2.sym} 10950 -10600 0 0 {name=X_1555_ }
C {devices/lab_pin.sym} 10890 -10490 0 0 {name=p4847 lab=_2108_/A }
C {devices/lab_pin.sym} 10890 -10450 0 0 {name=p4848 lab=_2456_/Q }
C {devices/lab_pin.sym} 11010 -10470 0 1 {name=p4849 lab=_2107_/X }
C {sky130_stdcells/and2_4.sym} 10950 -10470 0 0 {name=X_2107_ }
C {devices/lab_pin.sym} 10910 -10340 0 0 {name=p4850 lab=_1486_/A }
C {devices/lab_pin.sym} 10990 -10340 0 1 {name=p4851 lab=_1505_/C }
C {sky130_stdcells/buf_2.sym} 10950 -10340 0 0 {name=X_1486_ }
C {devices/lab_pin.sym} 10890 -10230 0 0 {name=p4852 lab=_2038_/A }
C {devices/lab_pin.sym} 10890 -10190 0 0 {name=p4853 lab=_2038_/B }
C {devices/lab_pin.sym} 11010 -10210 0 1 {name=p4854 lab=_2039_/A }
C {sky130_stdcells/nand2_4.sym} 10950 -10210 0 0 {name=X_2038_ }
C {devices/lab_pin.sym} 10870 -10120 0 0 {name=p4855 lab=_1335_/C }
C {devices/lab_pin.sym} 10870 -10080 0 0 {name=p4856 lab=_1318_/B }
C {devices/lab_pin.sym} 10870 -10040 0 0 {name=p4857 lab=_1335_/D }
C {devices/lab_pin.sym} 10870 -10000 0 0 {name=p4858 lab=_1329_/X }
C {devices/lab_pin.sym} 10870 -9970 0 0 {name=p4859 lab=_1339_/X }
C {devices/lab_pin.sym} 11030 -10040 0 1 {name=p4860 lab=_1340_/Y }
C {sky130_stdcells/a41oi_4.sym} 10950 -10040 0 0 {name=X_1340_ }
C {devices/lab_pin.sym} 10890 -9900 0 0 {name=p4861 lab=_1268_/Y }
C {devices/lab_pin.sym} 10890 -9860 0 0 {name=p4862 lab=_2010_/B }
C {devices/lab_pin.sym} 10890 -9820 0 0 {name=p4863 lab=_1271_/C }
C {devices/lab_pin.sym} 11010 -9860 0 1 {name=p4864 lab=_2643_/D }
C {sky130_stdcells/and3_4.sym} 10950 -9860 0 0 {name=X_1271_ }
C {devices/lab_pin.sym} 10870 -9760 0 0 {name=p4865 lab=_1466_/Y }
C {devices/lab_pin.sym} 10870 -9720 0 0 {name=p4866 lab=_1467_/Y }
C {devices/lab_pin.sym} 10870 -9680 0 0 {name=p4867 lab=_1537_/X }
C {devices/lab_pin.sym} 10870 -9640 0 0 {name=p4868 lab=_1548_/D }
C {devices/lab_pin.sym} 10870 -9600 0 0 {name=p4869 lab=_1488_/X }
C {devices/lab_pin.sym} 11030 -9680 0 1 {name=p4870 lab=_1538_/X }
C {sky130_stdcells/o41a_4.sym} 10950 -9680 0 0 {name=X_1538_ }
C {devices/lab_pin.sym} 10890 -9550 0 0 {name=p4871 lab=_1466_/Y }
C {devices/lab_pin.sym} 10890 -9510 0 0 {name=p4872 lab=_1467_/Y }
C {devices/lab_pin.sym} 10890 -9470 0 0 {name=p4873 lab=_1424_/Y }
C {devices/lab_pin.sym} 10890 -9430 0 0 {name=p4874 lab=_1548_/D }
C {devices/lab_pin.sym} 11010 -9490 0 1 {name=p4875 lab=_1469_/Y }
C {sky130_stdcells/nor4_4.sym} 10950 -9490 0 0 {name=X_1469_ }
C {devices/lab_pin.sym} 10860 -9340 0 0 {name=p4876 lab=_2606_/CLK }
C {devices/lab_pin.sym} 10860 -9320 0 0 {name=p4877 lab=_1792_/X }
C {devices/lab_pin.sym} 11040 -9340 0 1 {name=p4878 lab=_1420_/A }
C {sky130_stdcells/dfxtp_4.sym} 10950 -9330 0 0 {name=X_2587_ }
C {devices/lab_pin.sym} 10890 -9210 0 0 {name=p4879 lab=_2604_/Q }
C {devices/lab_pin.sym} 10890 -9170 0 0 {name=p4880 lab=_2603_/Q }
C {devices/lab_pin.sym} 11010 -9190 0 1 {name=p4881 lab=_1667_/C }
C {sky130_stdcells/nor2_4.sym} 10950 -9190 0 0 {name=X_1607_ }
C {devices/lab_pin.sym} 10860 -9060 0 0 {name=p4882 lab=_2513_/CLK }
C {devices/lab_pin.sym} 10860 -9040 0 0 {name=p4883 lab=_1955_/X }
C {devices/lab_pin.sym} 11040 -9060 0 1 {name=p4884 lab=DATA_TO_HASH[3] }
C {sky130_stdcells/dfxtp_4.sym} 10950 -9050 0 0 {name=X_2510_ }
C {devices/lab_pin.sym} 10860 -8920 0 0 {name=p4885 lab=_2372_/CLK }
C {devices/lab_pin.sym} 10860 -8900 0 0 {name=p4886 lab=_2371_/Q }
C {devices/lab_pin.sym} 11040 -8920 0 1 {name=p4887 lab=_2373_/D }
C {sky130_stdcells/dfxtp_4.sym} 10950 -8910 0 0 {name=X_2372_ }
C {devices/lab_pin.sym} 10910 -8780 0 0 {name=p4888 lab=_1323_/A }
C {devices/lab_pin.sym} 10990 -8780 0 1 {name=p4889 lab=_1323_/Y }
C {sky130_stdcells/inv_2.sym} 10950 -8780 0 0 {name=X_1323_ }
C {devices/lab_pin.sym} 10860 -8660 0 0 {name=p4890 lab=_2598_/CLK }
C {devices/lab_pin.sym} 10860 -8640 0 0 {name=p4891 lab=_2441_/D }
C {devices/lab_pin.sym} 11040 -8660 0 1 {name=p4892 lab=_2441_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10950 -8650 0 0 {name=X_2441_ }
C {devices/lab_pin.sym} 10910 -8520 0 0 {name=p4893 lab=_1185_/A }
C {devices/lab_pin.sym} 10990 -8520 0 1 {name=p4894 lab=_1188_/A }
C {sky130_stdcells/inv_2.sym} 10950 -8520 0 0 {name=X_1185_ }
C {devices/lab_pin.sym} 10910 -8400 0 0 {name=p4895 lab=_1374_/A }
C {devices/lab_pin.sym} 10990 -8400 0 1 {name=p4896 lab=_1254_/X }
C {sky130_stdcells/buf_2.sym} 10950 -8400 0 0 {name=X_1254_ }
C {devices/lab_pin.sym} 10860 -8280 0 0 {name=p4897 lab=_2638_/CLK }
C {devices/lab_pin.sym} 10860 -8260 0 0 {name=p4898 lab=_1290_/Y }
C {devices/lab_pin.sym} 11040 -8280 0 1 {name=p4899 lab=_1224_/A }
C {sky130_stdcells/dfxtp_4.sym} 10950 -8270 0 0 {name=X_2639_ }
C {devices/lab_pin.sym} 10860 -8140 0 0 {name=p4900 lab=_1969_/X }
C {sky130_stdcells/diode_2.sym} 10950 -8140 0 0 {name=XINSDIODE2_3 }
C {devices/lab_pin.sym} 10890 -8030 0 0 {name=p4901 lab=_1870_/X }
C {devices/lab_pin.sym} 10890 -7990 0 0 {name=p4902 lab=DATA_FROM_HASH[6] }
C {devices/lab_pin.sym} 11010 -8010 0 1 {name=p4903 lab=_2565_/D }
C {sky130_stdcells/and2_4.sym} 10950 -8010 0 0 {name=X_1872_ }
C {devices/lab_pin.sym} 10910 -7880 0 0 {name=p4904 lab=_1941_/A }
C {devices/lab_pin.sym} 10990 -7880 0 1 {name=p4905 lab=_1942_/B }
C {sky130_stdcells/inv_2.sym} 10950 -7880 0 0 {name=X_1941_ }
C {devices/lab_pin.sym} 10870 -7780 0 0 {name=p4906 lab=_1676_/B }
C {devices/lab_pin.sym} 10870 -7740 0 0 {name=p4907 lab=_1187_/A }
C {devices/lab_pin.sym} 10870 -7700 0 0 {name=p4908 lab=_1213_/X }
C {devices/lab_pin.sym} 11030 -7740 0 1 {name=p4909 lab=_2355_/Y }
C {sky130_stdcells/o21ai_4.sym} 10950 -7740 0 0 {name=X_2355_ }
C {devices/lab_pin.sym} 10910 -7600 0 0 {name=p4910 lab=_1270_/A }
C {devices/lab_pin.sym} 10990 -7600 0 1 {name=p4911 lab=_1306_/X }
C {sky130_stdcells/buf_2.sym} 10950 -7600 0 0 {name=X_1306_ }
C {devices/lab_pin.sym} 10870 -7520 0 0 {name=p4912 lab=_1581_/X }
C {devices/lab_pin.sym} 10870 -7480 0 0 {name=p4913 lab=_2255_/Y }
C {devices/lab_pin.sym} 10870 -7440 0 0 {name=p4914 lab=_2278_/A }
C {devices/lab_pin.sym} 10870 -7400 0 0 {name=p4915 lab=_1925_/Y }
C {devices/lab_pin.sym} 10870 -7360 0 0 {name=p4916 lab=_2279_/X }
C {devices/lab_pin.sym} 11030 -7440 0 1 {name=p4917 lab=_2413_/D }
C {sky130_stdcells/o32ai_4.sym} 10950 -7440 0 0 {name=X_2286_ }
C {devices/lab_pin.sym} 10860 -7280 0 0 {name=p4918 lab=_2428_/CLK }
C {devices/lab_pin.sym} 10860 -7260 0 0 {name=p4919 lab=_2424_/D }
C {devices/lab_pin.sym} 11040 -7280 0 1 {name=p4920 lab=_1847_/A }
C {sky130_stdcells/dfxtp_4.sym} 10950 -7270 0 0 {name=X_2424_ }
C {devices/lab_pin.sym} 10910 -7140 0 0 {name=p4921 lab=_1237_/A }
C {devices/lab_pin.sym} 10990 -7140 0 1 {name=p4922 lab=_1238_/D }
C {sky130_stdcells/inv_2.sym} 10950 -7140 0 0 {name=X_1237_ }
C {devices/lab_pin.sym} 10870 -7060 0 0 {name=p4923 lab=_2136_/Y }
C {devices/lab_pin.sym} 10870 -7020 0 0 {name=p4924 lab=_2138_/Y }
C {devices/lab_pin.sym} 10870 -6980 0 0 {name=p4925 lab=_2120_/X }
C {devices/lab_pin.sym} 10870 -6940 0 0 {name=p4926 lab=_1960_/Y }
C {devices/lab_pin.sym} 10870 -6900 0 0 {name=p4927 lab=_2139_/X }
C {devices/lab_pin.sym} 11030 -6980 0 1 {name=p4928 lab=_2442_/D }
C {sky130_stdcells/o32ai_4.sym} 10950 -6980 0 0 {name=X_2140_ }
C {devices/lab_pin.sym} 10910 -6820 0 0 {name=p4929 lab=_2071_/A }
C {devices/lab_pin.sym} 10990 -6820 0 1 {name=p4930 lab=_2071_/Y }
C {sky130_stdcells/inv_2.sym} 10950 -6820 0 0 {name=X_2071_ }
C {devices/lab_pin.sym} 10870 -6720 0 0 {name=p4931 lab=_1843_/Y }
C {devices/lab_pin.sym} 10870 -6680 0 0 {name=p4932 lab=_1853_/Y }
C {devices/lab_pin.sym} 10870 -6640 0 0 {name=p4933 lab=_1854_/X }
C {devices/lab_pin.sym} 11030 -6680 0 1 {name=p4934 lab=_1855_/Y }
C {sky130_stdcells/o21ai_4.sym} 10950 -6680 0 0 {name=X_1855_ }
C {devices/lab_pin.sym} 10890 -6550 0 0 {name=p4935 lab=_1930_/A }
C {devices/lab_pin.sym} 10890 -6510 0 0 {name=p4936 lab=_1923_/Y }
C {devices/lab_pin.sym} 11010 -6530 0 1 {name=p4937 lab=_1924_/Y }
C {sky130_stdcells/nor2_4.sym} 10950 -6530 0 0 {name=X_1924_ }
C {devices/lab_pin.sym} 10910 -6400 0 0 {name=p4938 lab=_2591_/Q }
C {devices/lab_pin.sym} 10990 -6400 0 1 {name=p4939 lab=_1786_/Y }
C {sky130_stdcells/inv_2.sym} 10950 -6400 0 0 {name=X_1786_ }
C {devices/lab_pin.sym} 10890 -6300 0 0 {name=p4940 lab=_2338_/A }
C {devices/lab_pin.sym} 10890 -6260 0 0 {name=p4941 lab=_1188_/A }
C {devices/lab_pin.sym} 10890 -6220 0 0 {name=p4942 lab=_1680_/B }
C {devices/lab_pin.sym} 11010 -6260 0 1 {name=p4943 lab=_2338_/X }
C {sky130_stdcells/and3_4.sym} 10950 -6260 0 0 {name=X_2338_ }
C {devices/lab_pin.sym} 10870 -6160 0 0 {name=p4944 lab=_2268_/Y }
C {devices/lab_pin.sym} 10870 -6120 0 0 {name=p4945 lab=_2262_/X }
C {devices/lab_pin.sym} 10870 -6080 0 0 {name=p4946 lab=_2258_/X }
C {devices/lab_pin.sym} 10870 -6040 0 0 {name=p4947 lab=_1847_/Y }
C {devices/lab_pin.sym} 10870 -6000 0 0 {name=p4948 lab=_2264_/X }
C {devices/lab_pin.sym} 11030 -6080 0 1 {name=p4949 lab=_2424_/D }
C {sky130_stdcells/o32ai_4.sym} 10950 -6080 0 0 {name=X_2269_ }
C {devices/lab_pin.sym} 10860 -5920 0 0 {name=p4950 lab=_2408_/CLK }
C {devices/lab_pin.sym} 10860 -5900 0 0 {name=p4951 lab=_2407_/D }
C {devices/lab_pin.sym} 11040 -5920 0 1 {name=p4952 lab=_2300_/C }
C {sky130_stdcells/dfxtp_4.sym} 10950 -5910 0 0 {name=X_2407_ }
C {devices/lab_pin.sym} 10910 -5780 0 0 {name=p4953 lab=_1571_/A }
C {devices/lab_pin.sym} 10990 -5780 0 1 {name=p4954 lab=_1860_/B }
C {sky130_stdcells/buf_2.sym} 10950 -5780 0 0 {name=X_1571_ }
C {devices/lab_pin.sym} 10910 -5660 0 0 {name=p4955 lab=_1613_/Y }
C {devices/lab_pin.sym} 10990 -5660 0 1 {name=p4956 lab=_1640_/X }
C {sky130_stdcells/buf_2.sym} 10950 -5660 0 0 {name=X_1640_ }
C {devices/lab_pin.sym} 10910 -5540 0 0 {name=p4957 lab=_2123_/A }
C {devices/lab_pin.sym} 10990 -5540 0 1 {name=p4958 lab=_2125_/A }
C {sky130_stdcells/buf_2.sym} 10950 -5540 0 0 {name=X_2123_ }
C {devices/lab_pin.sym} 10910 -5420 0 0 {name=p4959 lab=_2478_/Q }
C {devices/lab_pin.sym} 10990 -5420 0 1 {name=p4960 lab=_2062_/B }
C {sky130_stdcells/buf_2.sym} 10950 -5420 0 0 {name=X_2054_ }
C {devices/lab_pin.sym} 10910 -5300 0 0 {name=p4961 lab=_1838_/A }
C {devices/lab_pin.sym} 10990 -5300 0 1 {name=p4962 lab=_1840_/B }
C {sky130_stdcells/buf_2.sym} 10950 -5300 0 0 {name=X_1838_ }
C {devices/lab_pin.sym} 10890 -5190 0 0 {name=p4963 lab=_1901_/X }
C {devices/lab_pin.sym} 10890 -5150 0 0 {name=p4964 lab=_1906_/Y }
C {devices/lab_pin.sym} 11010 -5170 0 1 {name=p4965 lab=_2540_/D }
C {sky130_stdcells/nor2_4.sym} 10950 -5170 0 0 {name=X_1907_ }
C {devices/lab_pin.sym} 10870 -5080 0 0 {name=p4966 lab=_1486_/A }
C {devices/lab_pin.sym} 10870 -5040 0 0 {name=p4967 lab=_1764_/Y }
C {devices/lab_pin.sym} 10870 -5000 0 0 {name=p4968 lab=_1766_/Y }
C {devices/lab_pin.sym} 10870 -4960 0 0 {name=p4969 lab=_1767_/X }
C {devices/lab_pin.sym} 10870 -4920 0 0 {name=p4970 lab=_1768_/X }
C {devices/lab_pin.sym} 11030 -5000 0 1 {name=p4971 lab=_1769_/X }
C {sky130_stdcells/a2111o_4.sym} 10950 -5000 0 0 {name=X_1769_ }
C {devices/lab_pin.sym} 10910 -4840 0 0 {name=p4972 lab=_1436_/C }
C {devices/lab_pin.sym} 10990 -4840 0 1 {name=p4973 lab=_1494_/B }
C {sky130_stdcells/buf_2.sym} 10950 -4840 0 0 {name=X_1485_ }
C {devices/lab_pin.sym} 10910 -4720 0 0 {name=p4974 lab=_2447_/Q }
C {devices/lab_pin.sym} 10990 -4720 0 1 {name=p4975 lab=_1623_/Y }
C {sky130_stdcells/inv_2.sym} 10950 -4720 0 0 {name=X_1623_ }
C {devices/lab_pin.sym} 10910 -4600 0 0 {name=p4976 lab=_1189_/Y }
C {devices/lab_pin.sym} 10990 -4600 0 1 {name=p4977 lab=_1555_/A }
C {sky130_stdcells/buf_2.sym} 10950 -4600 0 0 {name=X_1554_ }
C {devices/ipin.sym} 280 -520 0 0 {name=g0 lab=DATA_AVAILABLE[0:3]  }
C {devices/ipin.sym} 280 -500 0 0 {name=g1 lab=DATA_FROM_HASH[0:7]  }
C {devices/ipin.sym} 280 -480 0 0 {name=g2 lab=EXT_RESET_N_fromHost  }
C {devices/ipin.sym} 280 -460 0 0 {name=g3 lab=ID_fromClient  }
C {devices/ipin.sym} 280 -440 0 0 {name=g4 lab=IRQ_OUT_fromClient  }
C {devices/ipin.sym} 280 -420 0 0 {name=g5 lab=M1_CLK_IN  }
C {devices/ipin.sym} 280 -400 0 0 {name=g6 lab=M1_CLK_SELECT  }
C {devices/ipin.sym} 280 -380 0 0 {name=g7 lab=MISO_fromClient  }
C {devices/ipin.sym} 280 -360 0 0 {name=g8 lab=MOSI_fromHost  }
C {devices/ipin.sym} 280 -340 0 0 {name=g9 lab=PLL_INPUT  }
C {devices/ipin.sym} 280 -320 0 0 {name=g10 lab=S1_CLK_IN  }
C {devices/ipin.sym} 280 -300 0 0 {name=g11 lab=S1_CLK_SELECT  }
C {devices/ipin.sym} 280 -280 0 0 {name=g12 lab=SCLK_fromHost  }
C {devices/ipin.sym} 280 -260 0 0 {name=g13 lab=SCSN_fromHost  }
C {devices/ipin.sym} 280 -240 0 0 {name=g14 lab=THREAD_COUNT[0:3]  }
C {devices/opin.sym} 520 -520 0 0 {name=g15 lab=CLK_LED  }
C {devices/opin.sym} 520 -500 0 0 {name=g16 lab=DATA_TO_HASH[0:7]  }
C {devices/opin.sym} 520 -480 0 0 {name=g17 lab=EXT_RESET_N_toClient  }
C {devices/opin.sym} 520 -460 0 0 {name=g18 lab=HASH_ADDR[0:5]  }
C {devices/opin.sym} 520 -440 0 0 {name=g19 lab=HASH_EN  }
C {devices/opin.sym} 520 -420 0 0 {name=g20 lab=HASH_LED  }
C {devices/opin.sym} 520 -400 0 0 {name=g21 lab=ID_toHost  }
C {devices/opin.sym} 520 -380 0 0 {name=g22 lab=IRQ_OUT_toHost  }
C {devices/opin.sym} 520 -360 0 0 {name=g23 lab=MACRO_RD_SELECT[0:3]  }
C {devices/opin.sym} 520 -340 0 0 {name=g24 lab=MACRO_WR_SELECT[0:3]  }
C {devices/opin.sym} 520 -320 0 0 {name=g25 lab=MISO_toHost  }
C {devices/opin.sym} 520 -300 0 0 {name=g26 lab=MOSI_toClient  }
C {devices/opin.sym} 520 -280 0 0 {name=g27 lab=SCLK_toClient  }
C {devices/opin.sym} 520 -260 0 0 {name=g28 lab=SCSN_toClient  }
C {devices/opin.sym} 520 -240 0 0 {name=g29 lab=m1_clk_local  }
C {devices/opin.sym} 520 -220 0 0 {name=g30 lab=one  }
C {devices/opin.sym} 520 -200 0 0 {name=g31 lab=zero  }
C {devices/title.sym} 180 -40 0 0 {name=l2 author="Stefan Schippers"}
