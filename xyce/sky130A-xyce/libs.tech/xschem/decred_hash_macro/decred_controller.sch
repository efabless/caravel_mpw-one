v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {devices/lab_pin.sym} 710 -21950 0 0 {name=p0 lab=_2043_/C }
C {devices/lab_pin.sym} 710 -21910 0 0 {name=p1 lab=_2047_/A }
C {devices/lab_pin.sym} 710 -21870 0 0 {name=p2 lab=_2043_/D }
C {devices/lab_pin.sym} 710 -21830 0 0 {name=p3 lab=_2037_/D }
C {devices/lab_pin.sym} 830 -21890 0 1 {name=p4 lab=_2038_/B }
C {sky130_stdcells/nand4_4.sym} 770 -21890 0 0 {name=X_2037_ }
C {devices/lab_pin.sym} 710 -21750 0 0 {name=p5 lab=_1222_/A }
C {devices/lab_pin.sym} 710 -21710 0 0 {name=p6 lab=SCSN_fromHost }
C {devices/lab_pin.sym} 830 -21730 0 1 {name=p7 lab=_2106_/X }
C {sky130_stdcells/or2_4.sym} 770 -21730 0 0 {name=X_2106_ }
C {devices/lab_pin.sym} 730 -21600 0 0 {name=p8 lab=_1270_/A }
C {devices/lab_pin.sym} 810 -21600 0 1 {name=p9 lab=_2010_/B }
C {sky130_stdcells/buf_2.sym} 770 -21600 0 0 {name=X_1270_ }
C {devices/lab_pin.sym} 710 -21490 0 0 {name=p10 lab=_1426_/A }
C {devices/lab_pin.sym} 710 -21450 0 0 {name=p11 lab=_1428_/D }
C {devices/lab_pin.sym} 830 -21470 0 1 {name=p12 lab=_1609_/B }
C {sky130_stdcells/nor2_4.sym} 770 -21470 0 0 {name=X_1606_ }
C {devices/lab_pin.sym} 690 -21360 0 0 {name=p13 lab=_2618_/Q }
C {devices/lab_pin.sym} 690 -21320 0 0 {name=p14 lab=_1397_/Y }
C {devices/lab_pin.sym} 690 -21280 0 0 {name=p15 lab=_1398_/Y }
C {devices/lab_pin.sym} 850 -21320 0 1 {name=p16 lab=_1400_/A }
C {sky130_stdcells/a21o_4.sym} 770 -21320 0 0 {name=X_1399_ }
C {devices/lab_pin.sym} 730 -21180 0 0 {name=p17 lab=_1424_/Y }
C {devices/lab_pin.sym} 810 -21180 0 1 {name=p18 lab=_1537_/X }
C {sky130_stdcells/buf_2.sym} 770 -21180 0 0 {name=X_1537_ }
C {devices/lab_pin.sym} 730 -21060 0 0 {name=p19 lab=_1428_/Y }
C {devices/lab_pin.sym} 810 -21060 0 1 {name=p20 lab=_1548_/D }
C {sky130_stdcells/buf_2.sym} 770 -21060 0 0 {name=X_1468_ }
C {devices/lab_pin.sym} 680 -20940 0 0 {name=p21 lab=_2606_/CLK }
C {devices/lab_pin.sym} 680 -20920 0 0 {name=p22 lab=_2586_/D }
C {devices/lab_pin.sym} 860 -20940 0 1 {name=p23 lab=_1459_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -20930 0 0 {name=X_2586_ }
C {devices/lab_pin.sym} 680 -20800 0 0 {name=p24 lab=_2598_/CLK }
C {devices/lab_pin.sym} 680 -20780 0 0 {name=p25 lab=_2143_/Y }
C {devices/lab_pin.sym} 860 -20800 0 1 {name=p26 lab=_1964_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -20790 0 0 {name=X_2440_ }
C {devices/lab_pin.sym} 680 -20660 0 0 {name=p27 lab=_2370_/CLK }
C {devices/lab_pin.sym} 680 -20640 0 0 {name=p28 lab=_2371_/D }
C {devices/lab_pin.sym} 860 -20660 0 1 {name=p29 lab=_2371_/Q }
C {sky130_stdcells/dfxtp_4.sym} 770 -20650 0 0 {name=X_2371_ }
C {devices/lab_pin.sym} 730 -20520 0 0 {name=p30 lab=_2363_/Q }
C {devices/lab_pin.sym} 810 -20520 0 1 {name=p31 lab=_1374_/A }
C {sky130_stdcells/inv_2.sym} 770 -20520 0 0 {name=X_1253_ }
C {devices/lab_pin.sym} 710 -20420 0 0 {name=p32 lab=_1239_/Y }
C {devices/lab_pin.sym} 710 -20380 0 0 {name=p33 lab=_1321_/X }
C {devices/lab_pin.sym} 710 -20340 0 0 {name=p34 lab=_1316_/D }
C {devices/lab_pin.sym} 830 -20380 0 1 {name=p35 lab=_1323_/A }
C {sky130_stdcells/nand3_4.sym} 770 -20380 0 0 {name=X_1322_ }
C {devices/lab_pin.sym} 730 -20240 0 0 {name=p36 lab=clkbuf_0_m1_clk_local/X }
C {devices/lab_pin.sym} 810 -20240 0 1 {name=p37 lab=clkbuf_2_1_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 770 -20240 0 0 {name=Xclkbuf_1_0_0_m1_clk_local }
C {devices/lab_pin.sym} 730 -20120 0 0 {name=p38 lab=_1528_/A }
C {devices/lab_pin.sym} 810 -20120 0 1 {name=p39 lab=_1185_/A }
C {sky130_stdcells/buf_2.sym} 770 -20120 0 0 {name=X_1184_ }
C {devices/lab_pin.sym} 680 -20000 0 0 {name=p40 lab=_2570_/CLK }
C {devices/lab_pin.sym} 680 -19980 0 0 {name=p41 lab=_2569_/D }
C {devices/lab_pin.sym} 860 -20000 0 1 {name=p42 lab=_1735_/D }
C {sky130_stdcells/dfxtp_4.sym} 770 -19990 0 0 {name=X_2569_ }
C {devices/lab_pin.sym} 680 -19860 0 0 {name=p43 lab=_2638_/CLK }
C {devices/lab_pin.sym} 680 -19840 0 0 {name=p44 lab=_2638_/D }
C {devices/lab_pin.sym} 860 -19860 0 1 {name=p45 lab=_1295_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -19850 0 0 {name=X_2638_ }
C {devices/lab_pin.sym} 680 -19720 0 0 {name=p46 lab=_1955_/X }
C {sky130_stdcells/diode_2.sym} 770 -19720 0 0 {name=XINSDIODE2_4 }
C {devices/lab_pin.sym} 710 -19610 0 0 {name=p47 lab=_1870_/X }
C {devices/lab_pin.sym} 710 -19570 0 0 {name=p48 lab=DATA_FROM_HASH[7] }
C {devices/lab_pin.sym} 830 -19590 0 1 {name=p49 lab=_2566_/D }
C {sky130_stdcells/and2_4.sym} 770 -19590 0 0 {name=X_1871_ }
C {devices/lab_pin.sym} 710 -19470 0 0 {name=p50 lab=_1938_/A }
C {devices/lab_pin.sym} 710 -19430 0 0 {name=p51 lab=_1746_/Y }
C {devices/lab_pin.sym} 830 -19450 0 1 {name=p52 lab=_1940_/Y }
C {sky130_stdcells/nor2_4.sym} 770 -19450 0 0 {name=X_1940_ }
C {devices/lab_pin.sym} 680 -19320 0 0 {name=p53 lab=_2408_/CLK }
C {devices/lab_pin.sym} 680 -19300 0 0 {name=p54 lab=_2271_/Y }
C {devices/lab_pin.sym} 860 -19320 0 1 {name=p55 lab=_1746_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -19310 0 0 {name=X_2423_ }
C {devices/lab_pin.sym} 710 -19190 0 0 {name=p56 lab=_1236_/A }
C {devices/lab_pin.sym} 710 -19150 0 0 {name=p57 lab=_2623_/Q }
C {devices/lab_pin.sym} 830 -19170 0 1 {name=p58 lab=_1237_/A }
C {sky130_stdcells/nand2_4.sym} 770 -19170 0 0 {name=X_1236_ }
C {devices/lab_pin.sym} 690 -19060 0 0 {name=p59 lab=_2097_/B }
C {devices/lab_pin.sym} 690 -19020 0 0 {name=p60 lab=_1179_/A }
C {devices/lab_pin.sym} 690 -18980 0 0 {name=p61 lab=_2353_/X }
C {devices/lab_pin.sym} 850 -19020 0 1 {name=p62 lab=_2354_/Y }
C {sky130_stdcells/o21ai_4.sym} 770 -19020 0 0 {name=X_2354_ }
C {devices/lab_pin.sym} 710 -18910 0 0 {name=p63 lab=_1318_/B }
C {devices/lab_pin.sym} 710 -18870 0 0 {name=p64 lab=_1308_/C }
C {devices/lab_pin.sym} 710 -18830 0 0 {name=p65 lab=_1243_/X }
C {devices/lab_pin.sym} 710 -18790 0 0 {name=p66 lab=_1246_/D }
C {devices/lab_pin.sym} 830 -18850 0 1 {name=p67 lab=_1305_/X }
C {sky130_stdcells/and4_4.sym} 770 -18850 0 0 {name=X_1305_ }
C {devices/lab_pin.sym} 730 -18700 0 0 {name=p68 lab=m1_clk_local }
C {devices/lab_pin.sym} 810 -18700 0 1 {name=p69 lab=clkbuf_0_m1_clk_local/X }
C {sky130_stdcells/clkbuf_16.sym} 770 -18700 0 0 {name=Xclkbuf_0_m1_clk_local }
C {devices/lab_pin.sym} 690 -18620 0 0 {name=p70 lab=_2276_/X }
C {devices/lab_pin.sym} 690 -18580 0 0 {name=p71 lab=_2253_/Y }
C {devices/lab_pin.sym} 690 -18540 0 0 {name=p72 lab=_2278_/X }
C {devices/lab_pin.sym} 690 -18500 0 0 {name=p73 lab=_1923_/Y }
C {devices/lab_pin.sym} 690 -18460 0 0 {name=p74 lab=_2280_/X }
C {devices/lab_pin.sym} 850 -18540 0 1 {name=p75 lab=_2285_/Y }
C {sky130_stdcells/o32ai_4.sym} 770 -18540 0 0 {name=X_2285_ }
C {devices/lab_pin.sym} 730 -18380 0 0 {name=p76 lab=clkbuf_3_3_0_m1_clk_local/A }
C {devices/lab_pin.sym} 810 -18380 0 1 {name=p77 lab=clkbuf_4_7_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 770 -18380 0 0 {name=Xclkbuf_3_3_0_m1_clk_local }
C {devices/lab_pin.sym} 730 -18260 0 0 {name=p78 lab=_2070_/A }
C {devices/lab_pin.sym} 810 -18260 0 1 {name=p79 lab=_2070_/Y }
C {sky130_stdcells/inv_2.sym} 770 -18260 0 0 {name=X_2070_ }
C {devices/lab_pin.sym} 690 -18160 0 0 {name=p80 lab=_1783_/Y }
C {devices/lab_pin.sym} 690 -18120 0 0 {name=p81 lab=_1784_/Y }
C {devices/lab_pin.sym} 690 -18080 0 0 {name=p82 lab=_1781_/X }
C {devices/lab_pin.sym} 850 -18120 0 1 {name=p83 lab=_2588_/D }
C {sky130_stdcells/a21oi_4.sym} 770 -18120 0 0 {name=X_1785_ }
C {devices/lab_pin.sym} 710 -17990 0 0 {name=p84 lab=_1854_/A }
C {devices/lab_pin.sym} 710 -17950 0 0 {name=p85 lab=_1640_/X }
C {devices/lab_pin.sym} 830 -17970 0 1 {name=p86 lab=_1854_/X }
C {sky130_stdcells/or2_4.sym} 770 -17970 0 0 {name=X_1854_ }
C {devices/lab_pin.sym} 730 -17840 0 0 {name=p87 lab=_2151_/B }
C {devices/lab_pin.sym} 810 -17840 0 1 {name=p88 lab=_1923_/Y }
C {sky130_stdcells/inv_2.sym} 770 -17840 0 0 {name=X_1923_ }
C {devices/lab_pin.sym} 680 -17720 0 0 {name=p89 lab=_2408_/CLK }
C {devices/lab_pin.sym} 680 -17700 0 0 {name=p90 lab=_2303_/Y }
C {devices/lab_pin.sym} 860 -17720 0 1 {name=p91 lab=HASH_LED }
C {sky130_stdcells/dfxtp_4.sym} 770 -17710 0 0 {name=X_2406_ }
C {devices/lab_pin.sym} 730 -17580 0 0 {name=p92 lab=_2384_/Q }
C {devices/lab_pin.sym} 810 -17580 0 1 {name=p93 lab=_1219_/X }
C {sky130_stdcells/buf_2.sym} 770 -17580 0 0 {name=X_1219_ }
C {devices/lab_pin.sym} 710 -17480 0 0 {name=p94 lab=_2337_/A }
C {devices/lab_pin.sym} 710 -17440 0 0 {name=p95 lab=_1575_/Y }
C {devices/lab_pin.sym} 710 -17400 0 0 {name=p96 lab=_1683_/Y }
C {devices/lab_pin.sym} 830 -17440 0 1 {name=p97 lab=_2338_/A }
C {sky130_stdcells/nand3_4.sym} 770 -17440 0 0 {name=X_2337_ }
C {devices/lab_pin.sym} 710 -17310 0 0 {name=p98 lab=_1623_/Y }
C {devices/lab_pin.sym} 710 -17270 0 0 {name=p99 lab=_2428_/Q }
C {devices/lab_pin.sym} 830 -17290 0 1 {name=p100 lab=_2199_/Y }
C {sky130_stdcells/nand2_4.sym} 770 -17290 0 0 {name=X_2199_ }
C {devices/lab_pin.sym} 730 -17160 0 0 {name=p101 lab=_2268_/A }
C {devices/lab_pin.sym} 810 -17160 0 1 {name=p102 lab=_2268_/Y }
C {sky130_stdcells/inv_2.sym} 770 -17160 0 0 {name=X_2268_ }
C {devices/lab_pin.sym} 730 -17040 0 0 {name=p103 lab=_1570_/A }
C {devices/lab_pin.sym} 810 -17040 0 1 {name=p104 lab=_1571_/A }
C {sky130_stdcells/buf_2.sym} 770 -17040 0 0 {name=X_1570_ }
C {devices/lab_pin.sym} 710 -16940 0 0 {name=p105 lab=_1992_/A }
C {devices/lab_pin.sym} 710 -16900 0 0 {name=p106 lab=_2060_/A }
C {devices/lab_pin.sym} 710 -16860 0 0 {name=p107 lab=_1992_/D }
C {devices/lab_pin.sym} 830 -16900 0 1 {name=p108 lab=_2053_/Y }
C {sky130_stdcells/nor3_4.sym} 770 -16900 0 0 {name=X_2053_ }
C {devices/lab_pin.sym} 710 -16780 0 0 {name=p109 lab=_1874_/A }
C {devices/lab_pin.sym} 710 -16740 0 0 {name=p110 lab=_2121_/X }
C {devices/lab_pin.sym} 710 -16700 0 0 {name=p111 lab=_1420_/A }
C {devices/lab_pin.sym} 830 -16740 0 1 {name=p112 lab=_2122_/Y }
C {sky130_stdcells/nand3_4.sym} 770 -16740 0 0 {name=X_2122_ }
C {devices/lab_pin.sym} 730 -16600 0 0 {name=p113 lab=_1836_/X }
C {devices/lab_pin.sym} 810 -16600 0 1 {name=p114 lab=_2570_/D }
C {sky130_stdcells/inv_2.sym} 770 -16600 0 0 {name=X_1837_ }
C {devices/lab_pin.sym} 730 -16480 0 0 {name=p115 lab=_2154_/B }
C {devices/lab_pin.sym} 810 -16480 0 1 {name=p116 lab=_1906_/Y }
C {sky130_stdcells/inv_2.sym} 770 -16480 0 0 {name=X_1906_ }
C {devices/lab_pin.sym} 710 -16370 0 0 {name=p117 lab=_1438_/B }
C {devices/lab_pin.sym} 710 -16330 0 0 {name=p118 lab=_1768_/B }
C {devices/lab_pin.sym} 830 -16350 0 1 {name=p119 lab=_1768_/X }
C {sky130_stdcells/xor2_4.sym} 770 -16350 0 0 {name=X_1768_ }
C {devices/lab_pin.sym} 690 -16240 0 0 {name=p120 lab=_1693_/Y }
C {devices/lab_pin.sym} 690 -16200 0 0 {name=p121 lab=_1698_/Y }
C {devices/lab_pin.sym} 690 -16160 0 0 {name=p122 lab=_1454_/X }
C {devices/lab_pin.sym} 850 -16200 0 1 {name=p123 lab=_2594_/D }
C {sky130_stdcells/a21oi_4.sym} 770 -16200 0 0 {name=X_1699_ }
C {devices/lab_pin.sym} 730 -16060 0 0 {name=p124 lab=_2426_/Q }
C {devices/lab_pin.sym} 810 -16060 0 1 {name=p125 lab=_1622_/Y }
C {sky130_stdcells/inv_2.sym} 770 -16060 0 0 {name=X_1622_ }
C {devices/lab_pin.sym} 690 -15970 0 0 {name=p126 lab=_1490_/A }
C {devices/lab_pin.sym} 690 -15930 0 0 {name=p127 lab=_1527_/Y }
C {devices/lab_pin.sym} 690 -15890 0 0 {name=p128 lab=_1530_/Y }
C {devices/lab_pin.sym} 690 -15850 0 0 {name=p129 lab=_1552_/Y }
C {devices/lab_pin.sym} 850 -15910 0 1 {name=p130 lab=_1557_/A }
C {sky130_stdcells/a211o_4.sym} 770 -15910 0 0 {name=X_1553_ }
C {devices/lab_pin.sym} 730 -15760 0 0 {name=p131 lab=_1484_/A }
C {devices/lab_pin.sym} 810 -15760 0 1 {name=p132 lab=_1505_/B }
C {sky130_stdcells/buf_2.sym} 770 -15760 0 0 {name=X_1484_ }
C {devices/lab_pin.sym} 690 -15660 0 0 {name=p133 lab=_2037_/D }
C {devices/lab_pin.sym} 690 -15620 0 0 {name=p134 lab=_2035_/X }
C {devices/lab_pin.sym} 690 -15580 0 0 {name=p135 lab=_1374_/X }
C {devices/lab_pin.sym} 850 -15620 0 1 {name=p136 lab=_2038_/A }
C {sky130_stdcells/o21a_4.sym} 770 -15620 0 0 {name=X_2036_ }
C {devices/lab_pin.sym} 710 -15490 0 0 {name=p137 lab=_1222_/A }
C {devices/lab_pin.sym} 710 -15450 0 0 {name=p138 lab=_2105_/B }
C {devices/lab_pin.sym} 830 -15470 0 1 {name=p139 lab=_2105_/X }
C {sky130_stdcells/or2_4.sym} 770 -15470 0 0 {name=X_2105_ }
C {devices/lab_pin.sym} 730 -15340 0 0 {name=p140 lab=_1605_/A }
C {devices/lab_pin.sym} 810 -15340 0 1 {name=p141 lab=_1651_/A }
C {sky130_stdcells/buf_2.sym} 770 -15340 0 0 {name=X_1605_ }
C {devices/lab_pin.sym} 680 -15220 0 0 {name=p142 lab=_2581_/CLK }
C {devices/lab_pin.sym} 680 -15200 0 0 {name=p143 lab=_1796_/X }
C {devices/lab_pin.sym} 860 -15220 0 1 {name=p144 lab=_1477_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -15210 0 0 {name=X_2585_ }
C {devices/lab_pin.sym} 690 -15100 0 0 {name=p145 lab=_1525_/Y }
C {devices/lab_pin.sym} 690 -15060 0 0 {name=p146 lab=_1532_/Y }
C {devices/lab_pin.sym} 690 -15020 0 0 {name=p147 lab=_1535_/X }
C {devices/lab_pin.sym} 850 -15060 0 1 {name=p148 lab=_2604_/D }
C {sky130_stdcells/a21oi_4.sym} 770 -15060 0 0 {name=X_1536_ }
C {devices/lab_pin.sym} 690 -14940 0 0 {name=p149 lab=_2618_/Q }
C {devices/lab_pin.sym} 690 -14900 0 0 {name=p150 lab=_1397_/Y }
C {devices/lab_pin.sym} 690 -14860 0 0 {name=p151 lab=_1374_/X }
C {devices/lab_pin.sym} 850 -14900 0 1 {name=p152 lab=_1398_/Y }
C {sky130_stdcells/o21ai_4.sym} 770 -14900 0 0 {name=X_1398_ }
C {devices/lab_pin.sym} 730 -14760 0 0 {name=p153 lab=_2602_/Q }
C {devices/lab_pin.sym} 810 -14760 0 1 {name=p154 lab=_1467_/Y }
C {sky130_stdcells/inv_2.sym} 770 -14760 0 0 {name=X_1467_ }
C {devices/lab_pin.sym} 710 -14660 0 0 {name=p155 lab=_1395_/A }
C {devices/lab_pin.sym} 710 -14620 0 0 {name=p156 lab=_2019_/B }
C {devices/lab_pin.sym} 710 -14580 0 0 {name=p157 lab=_2019_/C }
C {devices/lab_pin.sym} 830 -14620 0 1 {name=p158 lab=_2019_/Y }
C {sky130_stdcells/nor3_4.sym} 770 -14620 0 0 {name=X_2019_ }
C {devices/lab_pin.sym} 680 -14480 0 0 {name=p159 lab=_2370_/CLK }
C {devices/lab_pin.sym} 680 -14460 0 0 {name=p160 lab=_2369_/Q }
C {devices/lab_pin.sym} 860 -14480 0 1 {name=p161 lab=_2371_/D }
C {sky130_stdcells/dfxtp_4.sym} 770 -14470 0 0 {name=X_2370_ }
C {devices/lab_pin.sym} 730 -14340 0 0 {name=p162 lab=_1241_/Y }
C {devices/lab_pin.sym} 810 -14340 0 1 {name=p163 lab=_1321_/X }
C {sky130_stdcells/buf_2.sym} 770 -14340 0 0 {name=X_1321_ }
C {devices/lab_pin.sym} 710 -14230 0 0 {name=p164 lab=_1271_/C }
C {devices/lab_pin.sym} 710 -14190 0 0 {name=p165 lab=_1251_/Y }
C {devices/lab_pin.sym} 830 -14210 0 1 {name=p166 lab=_1263_/A }
C {sky130_stdcells/nand2_4.sym} 770 -14210 0 0 {name=X_1252_ }
C {devices/lab_pin.sym} 690 -14100 0 0 {name=p167 lab=_2353_/A }
C {devices/lab_pin.sym} 690 -14060 0 0 {name=p168 lab=_1179_/X }
C {devices/lab_pin.sym} 690 -14020 0 0 {name=p169 lab=_1182_/X }
C {devices/lab_pin.sym} 850 -14060 0 1 {name=p170 lab=_1183_/Y }
C {sky130_stdcells/o21ai_4.sym} 770 -14060 0 0 {name=X_1183_ }
C {devices/lab_pin.sym} 730 -13920 0 0 {name=p171 lab=clkbuf_3_5_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 810 -13920 0 1 {name=p172 lab=clkbuf_4_9_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 770 -13920 0 0 {name=Xclkbuf_3_4_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 680 -13800 0 0 {name=p173 lab=_1920_/X }
C {sky130_stdcells/diode_2.sym} 770 -13800 0 0 {name=XINSDIODE2_5 }
C {devices/lab_pin.sym} 680 -13680 0 0 {name=p174 lab=_2470_/CLK }
C {devices/lab_pin.sym} 680 -13660 0 0 {name=p175 lab=_1971_/X }
C {devices/lab_pin.sym} 860 -13680 0 1 {name=p176 lab=MACRO_WR_SELECT[0] }
C {sky130_stdcells/dfxtp_4.sym} 770 -13670 0 0 {name=X_2499_ }
C {devices/lab_pin.sym} 680 -13540 0 0 {name=p177 lab=_2550_/CLK }
C {devices/lab_pin.sym} 680 -13520 0 0 {name=p178 lab=_2568_/D }
C {devices/lab_pin.sym} 860 -13540 0 1 {name=p179 lab=_1862_/B }
C {sky130_stdcells/dfxtp_4.sym} 770 -13530 0 0 {name=X_2568_ }
C {devices/lab_pin.sym} 680 -13400 0 0 {name=p180 lab=_2477_/CLK }
C {devices/lab_pin.sym} 680 -13380 0 0 {name=p181 lab=_2637_/D }
C {devices/lab_pin.sym} 860 -13400 0 1 {name=p182 lab=_1299_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -13390 0 0 {name=X_2637_ }
C {devices/lab_pin.sym} 690 -13280 0 0 {name=p183 lab=_1473_/B }
C {devices/lab_pin.sym} 690 -13240 0 0 {name=p184 lab=_1440_/B }
C {devices/lab_pin.sym} 690 -13200 0 0 {name=p185 lab=_1518_/Y }
C {devices/lab_pin.sym} 850 -13240 0 1 {name=p186 lab=_1519_/Y }
C {sky130_stdcells/o21ai_4.sym} 770 -13240 0 0 {name=X_1519_ }
C {devices/lab_pin.sym} 730 -13100 0 0 {name=p187 lab=_1840_/B }
C {devices/lab_pin.sym} 810 -13100 0 1 {name=p188 lab=_1870_/X }
C {sky130_stdcells/buf_2.sym} 770 -13100 0 0 {name=X_1870_ }
C {devices/lab_pin.sym} 710 -12990 0 0 {name=p189 lab=_2353_/A }
C {devices/lab_pin.sym} 710 -12950 0 0 {name=p190 lab=_1180_/Y }
C {devices/lab_pin.sym} 830 -12970 0 1 {name=p191 lab=_2353_/X }
C {sky130_stdcells/or2_4.sym} 770 -12970 0 0 {name=X_2353_ }
C {devices/lab_pin.sym} 680 -12840 0 0 {name=p192 lab=_2408_/CLK }
C {devices/lab_pin.sym} 680 -12820 0 0 {name=p193 lab=_2422_/D }
C {devices/lab_pin.sym} 860 -12840 0 1 {name=p194 lab=_1941_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -12830 0 0 {name=X_2422_ }
C {devices/lab_pin.sym} 730 -12700 0 0 {name=p195 lab=_1235_/A }
C {devices/lab_pin.sym} 810 -12700 0 1 {name=p196 lab=_1365_/D }
C {sky130_stdcells/inv_2.sym} 770 -12700 0 0 {name=X_1235_ }
C {devices/lab_pin.sym} 730 -12580 0 0 {name=p197 lab=_2635_/Q }
C {devices/lab_pin.sym} 810 -12580 0 1 {name=p198 lab=_1308_/C }
C {sky130_stdcells/buf_2.sym} 770 -12580 0 0 {name=X_1304_ }
C {devices/lab_pin.sym} 690 -12500 0 0 {name=p199 lab=_2276_/X }
C {devices/lab_pin.sym} 690 -12460 0 0 {name=p200 lab=_2133_/Y }
C {devices/lab_pin.sym} 690 -12420 0 0 {name=p201 lab=_2278_/X }
C {devices/lab_pin.sym} 690 -12380 0 0 {name=p202 lab=_1744_/B }
C {devices/lab_pin.sym} 690 -12340 0 0 {name=p203 lab=_2280_/X }
C {devices/lab_pin.sym} 850 -12420 0 1 {name=p204 lab=_2415_/D }
C {sky130_stdcells/o32ai_4.sym} 770 -12420 0 0 {name=X_2284_ }
C {devices/lab_pin.sym} 710 -12290 0 0 {name=p205 lab=_1999_/A }
C {devices/lab_pin.sym} 710 -12250 0 0 {name=p206 lab=_1999_/B }
C {devices/lab_pin.sym} 710 -12210 0 0 {name=p207 lab=_2011_/A }
C {devices/lab_pin.sym} 710 -12170 0 0 {name=p208 lab=_2492_/Q }
C {devices/lab_pin.sym} 830 -12230 0 1 {name=p209 lab=_2010_/C }
C {sky130_stdcells/nand4_4.sym} 770 -12230 0 0 {name=X_1999_ }
C {devices/lab_pin.sym} 710 -12090 0 0 {name=p210 lab=_1932_/A }
C {devices/lab_pin.sym} 710 -12050 0 0 {name=p211 lab=_2537_/Q }
C {devices/lab_pin.sym} 830 -12070 0 1 {name=p212 lab=_2531_/D }
C {sky130_stdcells/and2_4.sym} 770 -12070 0 0 {name=X_1922_ }
C {devices/lab_pin.sym} 710 -11950 0 0 {name=p213 lab=_1678_/Y }
C {devices/lab_pin.sym} 710 -11910 0 0 {name=p214 lab=_2349_/A }
C {devices/lab_pin.sym} 830 -11930 0 1 {name=p215 lab=_1784_/Y }
C {sky130_stdcells/nand2_4.sym} 770 -11930 0 0 {name=X_1784_ }
C {devices/lab_pin.sym} 690 -11820 0 0 {name=p216 lab=_1850_/X }
C {devices/lab_pin.sym} 690 -11780 0 0 {name=p217 lab=_1852_/X }
C {devices/lab_pin.sym} 690 -11740 0 0 {name=p218 lab=_1471_/X }
C {devices/lab_pin.sym} 850 -11780 0 1 {name=p219 lab=_1853_/Y }
C {sky130_stdcells/a21oi_4.sym} 770 -11780 0 0 {name=X_1853_ }
C {devices/lab_pin.sym} 690 -11660 0 0 {name=p220 lab=_1575_/Y }
C {devices/lab_pin.sym} 690 -11620 0 0 {name=p221 lab=_2328_/X }
C {devices/lab_pin.sym} 690 -11580 0 0 {name=p222 lab=_2335_/Y }
C {devices/lab_pin.sym} 850 -11620 0 1 {name=p223 lab=_2388_/D }
C {sky130_stdcells/o21ai_4.sym} 770 -11620 0 0 {name=X_2336_ }
C {devices/lab_pin.sym} 680 -11480 0 0 {name=p224 lab=_2557_/CLK }
C {devices/lab_pin.sym} 680 -11460 0 0 {name=p225 lab=_2305_/Y }
C {devices/lab_pin.sym} 860 -11480 0 1 {name=p226 lab=_1232_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -11470 0 0 {name=X_2405_ }
C {devices/lab_pin.sym} 710 -11350 0 0 {name=p227 lab=_1218_/A }
C {devices/lab_pin.sym} 710 -11310 0 0 {name=p228 lab=_1218_/B }
C {devices/lab_pin.sym} 830 -11330 0 1 {name=p229 lab=_1218_/Y }
C {sky130_stdcells/nand2_4.sym} 770 -11330 0 0 {name=X_1218_ }
C {devices/lab_pin.sym} 690 -11240 0 0 {name=p230 lab=_2266_/Y }
C {devices/lab_pin.sym} 690 -11200 0 0 {name=p231 lab=_2262_/X }
C {devices/lab_pin.sym} 690 -11160 0 0 {name=p232 lab=_2258_/X }
C {devices/lab_pin.sym} 690 -11120 0 0 {name=p233 lab=_1937_/Y }
C {devices/lab_pin.sym} 690 -11080 0 0 {name=p234 lab=_2264_/X }
C {devices/lab_pin.sym} 850 -11160 0 1 {name=p235 lab=_2425_/D }
C {sky130_stdcells/o32ai_4.sym} 770 -11160 0 0 {name=X_2267_ }
C {devices/lab_pin.sym} 710 -11020 0 0 {name=p236 lab=_2196_/Y }
C {devices/lab_pin.sym} 710 -10980 0 0 {name=p237 lab=_1708_/X }
C {devices/lab_pin.sym} 710 -10940 0 0 {name=p238 lab=_2198_/C }
C {devices/lab_pin.sym} 830 -10980 0 1 {name=p239 lab=_2198_/Y }
C {sky130_stdcells/nand3_4.sym} 770 -10980 0 0 {name=X_2198_ }
C {devices/lab_pin.sym} 690 -10860 0 0 {name=p240 lab=_2014_/X }
C {devices/lab_pin.sym} 690 -10820 0 0 {name=p241 lab=_2040_/X }
C {devices/lab_pin.sym} 690 -10780 0 0 {name=p242 lab=_2051_/Y }
C {devices/lab_pin.sym} 850 -10820 0 1 {name=p243 lab=_2052_/Y }
C {sky130_stdcells/a21oi_4.sym} 770 -10820 0 0 {name=X_2052_ }
C {devices/lab_pin.sym} 730 -10680 0 0 {name=p244 lab=_1696_/A }
C {devices/lab_pin.sym} 810 -10680 0 1 {name=p245 lab=_2121_/X }
C {sky130_stdcells/buf_2.sym} 770 -10680 0 0 {name=X_2121_ }
C {devices/lab_pin.sym} 710 -10570 0 0 {name=p246 lab=_1901_/X }
C {devices/lab_pin.sym} 710 -10530 0 0 {name=p247 lab=_1905_/B }
C {devices/lab_pin.sym} 830 -10550 0 1 {name=p248 lab=_1905_/Y }
C {sky130_stdcells/nor2_4.sym} 770 -10550 0 0 {name=X_1905_ }
C {devices/lab_pin.sym} 690 -10440 0 0 {name=p249 lab=_1735_/C }
C {devices/lab_pin.sym} 690 -10400 0 0 {name=p250 lab=_1834_/Y }
C {devices/lab_pin.sym} 690 -10360 0 0 {name=p251 lab=_1835_/Y }
C {devices/lab_pin.sym} 850 -10400 0 1 {name=p252 lab=_1836_/X }
C {sky130_stdcells/a21o_4.sym} 770 -10400 0 0 {name=X_1836_ }
C {devices/lab_pin.sym} 710 -10290 0 0 {name=p253 lab=_1698_/A }
C {devices/lab_pin.sym} 710 -10250 0 0 {name=p254 lab=_1697_/Y }
C {devices/lab_pin.sym} 710 -10210 0 0 {name=p255 lab=_1689_/Y }
C {devices/lab_pin.sym} 710 -10170 0 0 {name=p256 lab=_2340_/B }
C {devices/lab_pin.sym} 830 -10230 0 1 {name=p257 lab=_1698_/Y }
C {sky130_stdcells/nand4_4.sym} 770 -10230 0 0 {name=X_1698_ }
C {devices/lab_pin.sym} 710 -10090 0 0 {name=p258 lab=_1483_/B }
C {devices/lab_pin.sym} 710 -10050 0 0 {name=p259 lab=_1767_/B }
C {devices/lab_pin.sym} 830 -10070 0 1 {name=p260 lab=_1767_/X }
C {sky130_stdcells/xor2_4.sym} 770 -10070 0 0 {name=X_1767_ }
C {devices/lab_pin.sym} 690 -9970 0 0 {name=p261 lab=_1771_/Y }
C {devices/lab_pin.sym} 690 -9930 0 0 {name=p262 lab=_2310_/X }
C {devices/lab_pin.sym} 690 -9890 0 0 {name=p263 lab=_1503_/A }
C {devices/lab_pin.sym} 690 -9850 0 0 {name=p264 lab=_2312_/X }
C {devices/lab_pin.sym} 850 -9910 0 1 {name=p265 lab=_2319_/X }
C {sky130_stdcells/a2bb2o_4.sym} 770 -9910 0 0 {name=X_2319_ }
C {devices/lab_pin.sym} 690 -9780 0 0 {name=p266 lab=_1537_/X }
C {devices/lab_pin.sym} 690 -9740 0 0 {name=p267 lab=_1548_/D }
C {devices/lab_pin.sym} 690 -9700 0 0 {name=p268 lab=_1544_/Y }
C {devices/lab_pin.sym} 850 -9740 0 1 {name=p269 lab=_1552_/Y }
C {sky130_stdcells/a21oi_4.sym} 770 -9740 0 0 {name=X_1552_ }
C {devices/lab_pin.sym} 690 -9630 0 0 {name=p270 lab=_2410_/Q }
C {devices/lab_pin.sym} 690 -9590 0 0 {name=p271 lab=_2181_/A }
C {devices/lab_pin.sym} 690 -9550 0 0 {name=p272 lab=_1617_/Y }
C {devices/lab_pin.sym} 690 -9510 0 0 {name=p273 lab=_1620_/Y }
C {devices/lab_pin.sym} 850 -9570 0 1 {name=p274 lab=_1621_/X }
C {sky130_stdcells/a211o_4.sym} 770 -9570 0 0 {name=X_1621_ }
C {devices/lab_pin.sym} 710 -9450 0 0 {name=p275 lab=_2104_/A }
C {devices/lab_pin.sym} 710 -9410 0 0 {name=p276 lab=_2091_/Y }
C {devices/lab_pin.sym} 710 -9370 0 0 {name=p277 lab=_2103_/Y }
C {devices/lab_pin.sym} 710 -9330 0 0 {name=p278 lab=_2468_/Q }
C {devices/lab_pin.sym} 830 -9390 0 1 {name=p279 lab=_2104_/X }
C {sky130_stdcells/and4_4.sym} 770 -9390 0 0 {name=X_2104_ }
C {devices/lab_pin.sym} 710 -9270 0 0 {name=p280 lab=_1482_/Y }
C {devices/lab_pin.sym} 710 -9230 0 0 {name=p281 lab=_1483_/B }
C {devices/lab_pin.sym} 710 -9190 0 0 {name=p282 lab=_2604_/Q }
C {devices/lab_pin.sym} 710 -9150 0 0 {name=p283 lab=_2603_/Q }
C {devices/lab_pin.sym} 830 -9210 0 1 {name=p284 lab=_1484_/A }
C {sky130_stdcells/and4_4.sym} 770 -9210 0 0 {name=X_1483_ }
C {devices/lab_pin.sym} 710 -9090 0 0 {name=p285 lab=_2029_/Y }
C {devices/lab_pin.sym} 710 -9050 0 0 {name=p286 lab=_2030_/X }
C {devices/lab_pin.sym} 710 -9010 0 0 {name=p287 lab=_2017_/B }
C {devices/lab_pin.sym} 710 -8970 0 0 {name=p288 lab=_2043_/D }
C {devices/lab_pin.sym} 830 -9030 0 1 {name=p289 lab=_2035_/X }
C {sky130_stdcells/and4_4.sym} 770 -9030 0 0 {name=X_2035_ }
C {devices/lab_pin.sym} 690 -8900 0 0 {name=p290 lab=_2575_/Q }
C {devices/lab_pin.sym} 690 -8860 0 0 {name=p291 lab=_1809_/X }
C {devices/lab_pin.sym} 690 -8820 0 0 {name=p292 lab=_1818_/X }
C {devices/lab_pin.sym} 850 -8860 0 1 {name=p293 lab=_2576_/D }
C {sky130_stdcells/o21a_4.sym} 770 -8860 0 0 {name=X_1819_ }
C {devices/lab_pin.sym} 710 -8730 0 0 {name=p294 lab=_1559_/B }
C {devices/lab_pin.sym} 710 -8690 0 0 {name=p295 lab=_2600_/Q }
C {devices/lab_pin.sym} 830 -8710 0 1 {name=p296 lab=_1605_/A }
C {sky130_stdcells/and2_4.sym} 770 -8710 0 0 {name=X_1604_ }
C {devices/lab_pin.sym} 690 -8600 0 0 {name=p297 lab=_1556_/A }
C {devices/lab_pin.sym} 690 -8560 0 0 {name=p298 lab=_1534_/X }
C {devices/lab_pin.sym} 690 -8520 0 0 {name=p299 lab=_1500_/X }
C {devices/lab_pin.sym} 850 -8560 0 1 {name=p300 lab=_1535_/X }
C {sky130_stdcells/a21o_4.sym} 770 -8560 0 0 {name=X_1535_ }
C {devices/lab_pin.sym} 680 -8420 0 0 {name=p301 lab=_2606_/CLK }
C {devices/lab_pin.sym} 680 -8400 0 0 {name=p302 lab=_1798_/X }
C {devices/lab_pin.sym} 860 -8420 0 1 {name=p303 lab=_1490_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -8410 0 0 {name=X_2584_ }
C {devices/lab_pin.sym} 710 -8300 0 0 {name=p304 lab=_1397_/A }
C {devices/lab_pin.sym} 710 -8260 0 0 {name=p305 lab=_1397_/B }
C {devices/lab_pin.sym} 710 -8220 0 0 {name=p306 lab=_1397_/C }
C {devices/lab_pin.sym} 830 -8260 0 1 {name=p307 lab=_1397_/Y }
C {sky130_stdcells/nor3_4.sym} 770 -8260 0 0 {name=X_1397_ }
C {devices/lab_pin.sym} 730 -8120 0 0 {name=p308 lab=_1466_/A }
C {devices/lab_pin.sym} 810 -8120 0 1 {name=p309 lab=_1466_/Y }
C {sky130_stdcells/inv_2.sym} 770 -8120 0 0 {name=X_1466_ }
C {devices/lab_pin.sym} 690 -8040 0 0 {name=p310 lab=_2488_/Q }
C {devices/lab_pin.sym} 690 -8000 0 0 {name=p311 lab=_2017_/X }
C {devices/lab_pin.sym} 690 -7960 0 0 {name=p312 lab=_1984_/A }
C {devices/lab_pin.sym} 690 -7920 0 0 {name=p313 lab=_1999_/A }
C {devices/lab_pin.sym} 690 -7890 0 0 {name=p314 lab=_2011_/A }
C {devices/lab_pin.sym} 850 -7960 0 1 {name=p315 lab=_2019_/C }
C {sky130_stdcells/a41oi_4.sym} 770 -7960 0 0 {name=X_2018_ }
C {devices/lab_pin.sym} 730 -7800 0 0 {name=p316 lab=_1319_/Y }
C {devices/lab_pin.sym} 810 -7800 0 1 {name=p317 lab=_2634_/D }
C {sky130_stdcells/inv_2.sym} 770 -7800 0 0 {name=X_1320_ }
C {devices/lab_pin.sym} 710 -7690 0 0 {name=p318 lab=_1182_/A }
C {devices/lab_pin.sym} 710 -7650 0 0 {name=p319 lab=_1194_/B }
C {devices/lab_pin.sym} 830 -7670 0 1 {name=p320 lab=_1182_/X }
C {sky130_stdcells/or2_4.sym} 770 -7670 0 0 {name=X_1182_ }
C {devices/lab_pin.sym} 730 -7540 0 0 {name=p321 lab=_1251_/A }
C {devices/lab_pin.sym} 810 -7540 0 1 {name=p322 lab=_1251_/Y }
C {sky130_stdcells/inv_2.sym} 770 -7540 0 0 {name=X_1251_ }
C {devices/lab_pin.sym} 680 -7420 0 0 {name=p323 lab=_2477_/CLK }
C {devices/lab_pin.sym} 680 -7400 0 0 {name=p324 lab=_2636_/D }
C {devices/lab_pin.sym} 860 -7420 0 1 {name=p325 lab=_2636_/Q }
C {sky130_stdcells/dfxtp_4.sym} 770 -7410 0 0 {name=X_2636_ }
C {devices/lab_pin.sym} 680 -7280 0 0 {name=p326 lab=_2498_/CLK }
C {devices/lab_pin.sym} 680 -7260 0 0 {name=p327 lab=_2498_/D }
C {devices/lab_pin.sym} 860 -7280 0 1 {name=p328 lab=_1973_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -7270 0 0 {name=X_2498_ }
C {devices/lab_pin.sym} 680 -7140 0 0 {name=p329 lab=_2498_/CLK }
C {devices/lab_pin.sym} 680 -7120 0 0 {name=p330 lab=_1869_/Y }
C {devices/lab_pin.sym} 860 -7140 0 1 {name=p331 lab=_2567_/Q }
C {sky130_stdcells/dfxtp_4.sym} 770 -7130 0 0 {name=X_2567_ }
C {devices/lab_pin.sym} 690 -7040 0 0 {name=p332 lab=_1473_/B }
C {devices/lab_pin.sym} 690 -7000 0 0 {name=p333 lab=_1482_/Y }
C {devices/lab_pin.sym} 690 -6960 0 0 {name=p334 lab=_1473_/C }
C {devices/lab_pin.sym} 690 -6920 0 0 {name=p335 lab=_1466_/A }
C {devices/lab_pin.sym} 690 -6890 0 0 {name=p336 lab=_2340_/C }
C {devices/lab_pin.sym} 850 -6960 0 1 {name=p337 lab=_1518_/Y }
C {sky130_stdcells/a41oi_4.sym} 770 -6960 0 0 {name=X_1518_ }
C {devices/lab_pin.sym} 710 -6810 0 0 {name=p338 lab=_1441_/Y }
C {devices/lab_pin.sym} 710 -6770 0 0 {name=p339 lab=_1449_/B }
C {devices/lab_pin.sym} 830 -6790 0 1 {name=p340 lab=_1449_/Y }
C {sky130_stdcells/nand2_4.sym} 770 -6790 0 0 {name=X_1449_ }
C {devices/lab_pin.sym} 710 -6680 0 0 {name=p341 lab=_2543_/Q }
C {devices/lab_pin.sym} 710 -6640 0 0 {name=p342 lab=_2544_/Q }
C {devices/lab_pin.sym} 710 -6600 0 0 {name=p343 lab=_2352_/C }
C {devices/lab_pin.sym} 830 -6640 0 1 {name=p344 lab=IRQ_OUT_toHost }
C {sky130_stdcells/or3_4.sym} 770 -6640 0 0 {name=X_2352_ }
C {devices/lab_pin.sym} 730 -6500 0 0 {name=p345 lab=_1258_/Y }
C {devices/lab_pin.sym} 810 -6500 0 1 {name=p346 lab=_1318_/B }
C {sky130_stdcells/buf_2.sym} 770 -6500 0 0 {name=X_1303_ }
C {devices/lab_pin.sym} 690 -6420 0 0 {name=p347 lab=_2276_/X }
C {devices/lab_pin.sym} 690 -6380 0 0 {name=p348 lab=_2130_/Y }
C {devices/lab_pin.sym} 690 -6340 0 0 {name=p349 lab=_2278_/X }
C {devices/lab_pin.sym} 690 -6300 0 0 {name=p350 lab=_1845_/B }
C {devices/lab_pin.sym} 690 -6260 0 0 {name=p351 lab=_2280_/X }
C {devices/lab_pin.sym} 850 -6340 0 1 {name=p352 lab=_2416_/D }
C {sky130_stdcells/o32ai_4.sym} 770 -6340 0 0 {name=X_2283_ }
C {devices/lab_pin.sym} 680 -6180 0 0 {name=p353 lab=_2408_/CLK }
C {devices/lab_pin.sym} 680 -6160 0 0 {name=p354 lab=_2421_/D }
C {devices/lab_pin.sym} 860 -6180 0 1 {name=p355 lab=_1944_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -6170 0 0 {name=X_2421_ }
C {devices/lab_pin.sym} 710 -6050 0 0 {name=p356 lab=_1385_/A }
C {devices/lab_pin.sym} 710 -6010 0 0 {name=p357 lab=_2621_/Q }
C {devices/lab_pin.sym} 830 -6030 0 1 {name=p358 lab=_1235_/A }
C {sky130_stdcells/nand2_4.sym} 770 -6030 0 0 {name=X_1234_ }
C {devices/lab_pin.sym} 710 -5910 0 0 {name=p359 lab=_1998_/A }
C {devices/lab_pin.sym} 710 -5870 0 0 {name=p360 lab=_2008_/A }
C {devices/lab_pin.sym} 830 -5890 0 1 {name=p361 lab=_1999_/B }
C {sky130_stdcells/nor2_4.sym} 770 -5890 0 0 {name=X_1998_ }
C {devices/lab_pin.sym} 680 -5760 0 0 {name=p362 lab=_2370_/CLK }
C {devices/lab_pin.sym} 680 -5740 0 0 {name=p363 lab=_1395_/Y }
C {devices/lab_pin.sym} 860 -5760 0 1 {name=p364 lab=_2619_/Q }
C {sky130_stdcells/dfxtp_4.sym} 770 -5750 0 0 {name=X_2619_ }
C {devices/lab_pin.sym} 730 -5620 0 0 {name=p365 lab=_1254_/X }
C {devices/lab_pin.sym} 810 -5620 0 1 {name=p366 lab=_1932_/A }
C {sky130_stdcells/buf_2.sym} 770 -5620 0 0 {name=X_1921_ }
C {devices/lab_pin.sym} 690 -5530 0 0 {name=p367 lab=_2444_/Q }
C {devices/lab_pin.sym} 690 -5490 0 0 {name=p368 lab=_1751_/A }
C {devices/lab_pin.sym} 690 -5450 0 0 {name=p369 lab=_1633_/X }
C {devices/lab_pin.sym} 690 -5410 0 0 {name=p370 lab=_1851_/Y }
C {devices/lab_pin.sym} 850 -5470 0 1 {name=p371 lab=_1852_/X }
C {sky130_stdcells/a211o_4.sym} 770 -5470 0 0 {name=X_1852_ }
C {devices/lab_pin.sym} 710 -5350 0 0 {name=p372 lab=_1678_/A }
C {devices/lab_pin.sym} 710 -5310 0 0 {name=p373 lab=_1783_/B }
C {devices/lab_pin.sym} 710 -5270 0 0 {name=p374 lab=_1779_/C }
C {devices/lab_pin.sym} 710 -5230 0 0 {name=p375 lab=_1783_/D }
C {devices/lab_pin.sym} 830 -5290 0 1 {name=p376 lab=_1783_/Y }
C {sky130_stdcells/nand4_4.sym} 770 -5290 0 0 {name=X_1783_ }
C {devices/lab_pin.sym} 710 -5170 0 0 {name=p377 lab=_2335_/A }
C {devices/lab_pin.sym} 710 -5130 0 0 {name=p378 lab=_2335_/B }
C {devices/lab_pin.sym} 710 -5090 0 0 {name=p379 lab=_1218_/B }
C {devices/lab_pin.sym} 710 -5050 0 0 {name=p380 lab=_1577_/X }
C {devices/lab_pin.sym} 830 -5110 0 1 {name=p381 lab=_2335_/Y }
C {sky130_stdcells/nand4_4.sym} 770 -5110 0 0 {name=X_2335_ }
C {devices/lab_pin.sym} 730 -4960 0 0 {name=p382 lab=_2266_/A }
C {devices/lab_pin.sym} 810 -4960 0 1 {name=p383 lab=_2266_/Y }
C {sky130_stdcells/inv_2.sym} 770 -4960 0 0 {name=X_2266_ }
C {devices/lab_pin.sym} 680 -4840 0 0 {name=p384 lab=_2408_/CLK }
C {devices/lab_pin.sym} 680 -4820 0 0 {name=p385 lab=_2307_/Y }
C {devices/lab_pin.sym} 860 -4840 0 1 {name=p386 lab=_2404_/Q }
C {sky130_stdcells/dfxtp_4.sym} 770 -4830 0 0 {name=X_2404_ }
C {devices/lab_pin.sym} 730 -4700 0 0 {name=p387 lab=_1185_/A }
C {devices/lab_pin.sym} 810 -4700 0 1 {name=p388 lab=_1218_/B }
C {sky130_stdcells/buf_2.sym} 770 -4700 0 0 {name=X_1217_ }
C {devices/lab_pin.sym} 710 -4590 0 0 {name=p389 lab=_2404_/Q }
C {devices/lab_pin.sym} 710 -4550 0 0 {name=p390 lab=_2175_/B }
C {devices/lab_pin.sym} 830 -4570 0 1 {name=p391 lab=_2198_/C }
C {sky130_stdcells/nand2_4.sym} 770 -4570 0 0 {name=X_2197_ }
C {devices/lab_pin.sym} 730 -4440 0 0 {name=p392 lab=_2123_/A }
C {devices/lab_pin.sym} 810 -4440 0 1 {name=p393 lab=_2120_/X }
C {sky130_stdcells/buf_2.sym} 770 -4440 0 0 {name=X_2120_ }
C {devices/lab_pin.sym} 690 -4340 0 0 {name=p394 lab=_2014_/X }
C {devices/lab_pin.sym} 690 -4300 0 0 {name=p395 lab=_2040_/X }
C {devices/lab_pin.sym} 690 -4260 0 0 {name=p396 lab=_1346_/X }
C {devices/lab_pin.sym} 850 -4300 0 1 {name=p397 lab=_2051_/Y }
C {sky130_stdcells/o21ai_4.sym} 770 -4300 0 0 {name=X_2051_ }
C {devices/lab_pin.sym} 690 -4180 0 0 {name=p398 lab=_1735_/C }
C {devices/lab_pin.sym} 690 -4140 0 0 {name=p399 lab=_1834_/Y }
C {devices/lab_pin.sym} 690 -4100 0 0 {name=p400 lab=_1831_/B }
C {devices/lab_pin.sym} 850 -4140 0 1 {name=p401 lab=_1835_/Y }
C {sky130_stdcells/o21ai_4.sym} 770 -4140 0 0 {name=X_1835_ }
C {devices/lab_pin.sym} 730 -4000 0 0 {name=p402 lab=_2431_/Q }
C {devices/lab_pin.sym} 810 -4000 0 1 {name=p403 lab=_1905_/B }
C {sky130_stdcells/inv_2.sym} 770 -4000 0 0 {name=X_1904_ }
C {devices/lab_pin.sym} 730 -3880 0 0 {name=p404 lab=_1697_/A }
C {devices/lab_pin.sym} 810 -3880 0 1 {name=p405 lab=_1697_/Y }
C {sky130_stdcells/inv_2.sym} 770 -3880 0 0 {name=X_1697_ }
C {devices/lab_pin.sym} 710 -3770 0 0 {name=p406 lab=_1438_/C }
C {devices/lab_pin.sym} 710 -3730 0 0 {name=p407 lab=_1766_/B }
C {devices/lab_pin.sym} 830 -3750 0 1 {name=p408 lab=_1766_/Y }
C {sky130_stdcells/nor2_4.sym} 770 -3750 0 0 {name=X_1766_ }
C {devices/lab_pin.sym} 730 -3620 0 0 {name=p409 lab=_2248_/X }
C {devices/lab_pin.sym} 810 -3620 0 1 {name=p410 lab=_2249_/X }
C {sky130_stdcells/buf_2.sym} 770 -3620 0 0 {name=X_2249_ }
C {devices/lab_pin.sym} 690 -3530 0 0 {name=p411 lab=_2158_/B }
C {devices/lab_pin.sym} 690 -3490 0 0 {name=p412 lab=_2311_/X }
C {devices/lab_pin.sym} 690 -3450 0 0 {name=p413 lab=_2253_/C }
C {devices/lab_pin.sym} 690 -3410 0 0 {name=p414 lab=_2313_/X }
C {devices/lab_pin.sym} 850 -3470 0 1 {name=p415 lab=_2318_/X }
C {sky130_stdcells/a2bb2o_4.sym} 770 -3470 0 0 {name=X_2318_ }
C {devices/lab_pin.sym} 690 -3340 0 0 {name=p416 lab=_1546_/X }
C {devices/lab_pin.sym} 690 -3300 0 0 {name=p417 lab=_1550_/Y }
C {devices/lab_pin.sym} 690 -3260 0 0 {name=p418 lab=_1454_/X }
C {devices/lab_pin.sym} 850 -3300 0 1 {name=p419 lab=_1551_/Y }
C {sky130_stdcells/a21oi_4.sym} 770 -3300 0 0 {name=X_1551_ }
C {devices/lab_pin.sym} 710 -3170 0 0 {name=p420 lab=_2175_/B }
C {devices/lab_pin.sym} 710 -3130 0 0 {name=p421 lab=_1620_/B }
C {devices/lab_pin.sym} 830 -3150 0 1 {name=p422 lab=_1620_/Y }
C {sky130_stdcells/nor2_4.sym} 770 -3150 0 0 {name=X_1620_ }
C {devices/lab_pin.sym} 710 -3040 0 0 {name=p423 lab=_1467_/Y }
C {devices/lab_pin.sym} 710 -3000 0 0 {name=p424 lab=_1424_/Y }
C {devices/lab_pin.sym} 710 -2960 0 0 {name=p425 lab=_1428_/Y }
C {devices/lab_pin.sym} 830 -3000 0 1 {name=p426 lab=_1482_/Y }
C {sky130_stdcells/nor3_4.sym} 770 -3000 0 0 {name=X_1482_ }
C {devices/lab_pin.sym} 730 -2860 0 0 {name=p427 lab=_2103_/A }
C {devices/lab_pin.sym} 810 -2860 0 1 {name=p428 lab=_2103_/Y }
C {sky130_stdcells/inv_2.sym} 770 -2860 0 0 {name=X_2103_ }
C {devices/lab_pin.sym} 690 -2760 0 0 {name=p429 lab=_2017_/C }
C {devices/lab_pin.sym} 690 -2720 0 0 {name=p430 lab=_2032_/X }
C {devices/lab_pin.sym} 690 -2680 0 0 {name=p431 lab=_2033_/Y }
C {devices/lab_pin.sym} 850 -2720 0 1 {name=p432 lab=_2034_/X }
C {sky130_stdcells/o21a_4.sym} 770 -2720 0 0 {name=X_2034_ }
C {devices/lab_pin.sym} 690 -2600 0 0 {name=p433 lab=_2576_/Q }
C {devices/lab_pin.sym} 690 -2560 0 0 {name=p434 lab=_1810_/X }
C {devices/lab_pin.sym} 690 -2520 0 0 {name=p435 lab=_1813_/X }
C {devices/lab_pin.sym} 850 -2560 0 1 {name=p436 lab=_1818_/X }
C {sky130_stdcells/o21a_4.sym} 770 -2560 0 0 {name=X_1818_ }
C {devices/lab_pin.sym} 690 -2440 0 0 {name=p437 lab=_1745_/X }
C {devices/lab_pin.sym} 690 -2400 0 0 {name=p438 lab=_1748_/Y }
C {devices/lab_pin.sym} 690 -2360 0 0 {name=p439 lab=_1628_/X }
C {devices/lab_pin.sym} 850 -2400 0 1 {name=p440 lab=_1749_/X }
C {sky130_stdcells/a21o_4.sym} 770 -2400 0 0 {name=X_1749_ }
C {devices/lab_pin.sym} 730 -2260 0 0 {name=p441 lab=clkbuf_4_5_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 810 -2260 0 1 {name=p442 lab=_2557_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 770 -2260 0 0 {name=Xclkbuf_4_4_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 680 -2140 0 0 {name=p443 lab=_2570_/CLK }
C {devices/lab_pin.sym} 680 -2120 0 0 {name=p444 lab=_2652_/D }
C {devices/lab_pin.sym} 860 -2140 0 1 {name=p445 lab=_2097_/B }
C {sky130_stdcells/dfxtp_4.sym} 770 -2130 0 0 {name=X_2652_ }
C {devices/lab_pin.sym} 730 -2000 0 0 {name=p446 lab=_1534_/A }
C {devices/lab_pin.sym} 810 -2000 0 1 {name=p447 lab=_1534_/X }
C {sky130_stdcells/buf_2.sym} 770 -2000 0 0 {name=X_1534_ }
C {devices/lab_pin.sym} 730 -1880 0 0 {name=p448 lab=_1602_/Y }
C {devices/lab_pin.sym} 810 -1880 0 1 {name=p449 lab=_1603_/Y }
C {sky130_stdcells/inv_2.sym} 770 -1880 0 0 {name=X_1603_ }
C {devices/lab_pin.sym} 680 -1760 0 0 {name=p450 lab=_2606_/CLK }
C {devices/lab_pin.sym} 680 -1740 0 0 {name=p451 lab=_2583_/D }
C {devices/lab_pin.sym} 860 -1760 0 1 {name=p452 lab=_1497_/A }
C {sky130_stdcells/dfxtp_4.sym} 770 -1750 0 0 {name=X_2583_ }
C {devices/lab_pin.sym} 690 -1640 0 0 {name=p453 lab=_1458_/Y }
C {devices/lab_pin.sym} 690 -1600 0 0 {name=p454 lab=_1463_/Y }
C {devices/lab_pin.sym} 690 -1560 0 0 {name=p455 lab=_1464_/Y }
C {devices/lab_pin.sym} 850 -1600 0 1 {name=p456 lab=_2611_/D }
C {sky130_stdcells/a21oi_4.sym} 770 -1600 0 0 {name=X_1465_ }
C {devices/lab_pin.sym} 710 -1490 0 0 {name=p457 lab=_2047_/A }
C {devices/lab_pin.sym} 710 -1450 0 0 {name=p458 lab=_2017_/B }
C {devices/lab_pin.sym} 710 -1410 0 0 {name=p459 lab=_2017_/C }
C {devices/lab_pin.sym} 710 -1370 0 0 {name=p460 lab=_2017_/D }
C {devices/lab_pin.sym} 830 -1430 0 1 {name=p461 lab=_2017_/X }
C {sky130_stdcells/and4_4.sym} 770 -1430 0 0 {name=X_2017_ }
C {devices/lab_pin.sym} 730 -1280 0 0 {name=p462 lab=_1231_/B }
C {devices/lab_pin.sym} 810 -1280 0 1 {name=p463 lab=_1397_/A }
C {sky130_stdcells/inv_2.sym} 770 -1280 0 0 {name=X_1396_ }
C {devices/lab_pin.sym} 730 -1160 0 0 {name=p464 lab=_1180_/Y }
C {devices/lab_pin.sym} 810 -1160 0 1 {name=p465 lab=_1194_/B }
C {sky130_stdcells/buf_2.sym} 770 -1160 0 0 {name=X_1181_ }
C {devices/lab_pin.sym} 710 -1070 0 0 {name=p466 lab=_1262_/C }
C {devices/lab_pin.sym} 710 -1030 0 0 {name=p467 lab=_1277_/B }
C {devices/lab_pin.sym} 710 -990 0 0 {name=p468 lab=_1277_/D }
C {devices/lab_pin.sym} 710 -950 0 0 {name=p469 lab=_1249_/Y }
C {devices/lab_pin.sym} 830 -1010 0 1 {name=p470 lab=_1271_/C }
C {sky130_stdcells/nand4_4.sym} 770 -1010 0 0 {name=X_1250_ }
C {devices/lab_pin.sym} 680 -860 0 0 {name=p471 lab=_2477_/CLK }
C {devices/lab_pin.sym} 680 -840 0 0 {name=p472 lab=_2635_/D }
C {devices/lab_pin.sym} 860 -860 0 1 {name=p473 lab=_2635_/Q }
C {sky130_stdcells/dfxtp_4.sym} 770 -850 0 0 {name=X_2635_ }
C {devices/lab_pin.sym} 6310 -21940 0 0 {name=p474 lab=clkbuf_4_9_0_m1_clk_local/A }
C {devices/lab_pin.sym} 6390 -21940 0 1 {name=p475 lab=_2618_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 6350 -21940 0 0 {name=Xclkbuf_4_8_0_m1_clk_local }
C {devices/lab_pin.sym} 6260 -21820 0 0 {name=p476 lab=_2496_/CLK }
C {devices/lab_pin.sym} 6260 -21800 0 0 {name=p477 lab=_1978_/X }
C {devices/lab_pin.sym} 6440 -21820 0 1 {name=p478 lab=_2497_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -21810 0 0 {name=X_2497_ }
C {devices/lab_pin.sym} 6260 -21680 0 0 {name=p479 lab=_2557_/CLK }
C {devices/lab_pin.sym} 6260 -21660 0 0 {name=p480 lab=_2566_/D }
C {devices/lab_pin.sym} 6440 -21680 0 1 {name=p481 lab=_2566_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -21670 0 0 {name=X_2566_ }
C {devices/lab_pin.sym} 6270 -21560 0 0 {name=p482 lab=_1513_/X }
C {devices/lab_pin.sym} 6270 -21520 0 0 {name=p483 lab=_1515_/Y }
C {devices/lab_pin.sym} 6270 -21480 0 0 {name=p484 lab=_1516_/X }
C {devices/lab_pin.sym} 6430 -21520 0 1 {name=p485 lab=_2606_/D }
C {sky130_stdcells/a21oi_4.sym} 6350 -21520 0 0 {name=X_1517_ }
C {devices/lab_pin.sym} 6310 -21380 0 0 {name=p486 lab=_1448_/A }
C {devices/lab_pin.sym} 6390 -21380 0 1 {name=p487 lab=_1449_/B }
C {sky130_stdcells/buf_2.sym} 6350 -21380 0 0 {name=X_1448_ }
C {devices/lab_pin.sym} 6310 -21260 0 0 {name=p488 lab=_1379_/A }
C {devices/lab_pin.sym} 6390 -21260 0 1 {name=p489 lab=_1379_/X }
C {sky130_stdcells/buf_2.sym} 6350 -21260 0 0 {name=X_1379_ }
C {devices/lab_pin.sym} 6260 -21140 0 0 {name=p490 lab=_2408_/CLK }
C {devices/lab_pin.sym} 6260 -21120 0 0 {name=p491 lab=_2420_/D }
C {devices/lab_pin.sym} 6440 -21140 0 1 {name=p492 lab=_2420_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -21130 0 0 {name=X_2420_ }
C {devices/lab_pin.sym} 6290 -21020 0 0 {name=p493 lab=_2351_/A }
C {devices/lab_pin.sym} 6290 -20980 0 0 {name=p494 lab=_2546_/Q }
C {devices/lab_pin.sym} 6290 -20940 0 0 {name=p495 lab=_2351_/C }
C {devices/lab_pin.sym} 6410 -20980 0 1 {name=p496 lab=_2352_/C }
C {sky130_stdcells/or3_4.sym} 6350 -20980 0 0 {name=X_2351_ }
C {devices/lab_pin.sym} 6290 -20870 0 0 {name=p497 lab=_1233_/A }
C {devices/lab_pin.sym} 6290 -20830 0 0 {name=p498 lab=_1397_/B }
C {devices/lab_pin.sym} 6290 -20790 0 0 {name=p499 lab=_1233_/C }
C {devices/lab_pin.sym} 6290 -20750 0 0 {name=p500 lab=_1397_/C }
C {devices/lab_pin.sym} 6410 -20810 0 1 {name=p501 lab=_1379_/A }
C {sky130_stdcells/nor4_4.sym} 6350 -20810 0 0 {name=X_1233_ }
C {devices/lab_pin.sym} 6310 -20660 0 0 {name=p502 lab=_1301_/Y }
C {devices/lab_pin.sym} 6390 -20660 0 1 {name=p503 lab=_2637_/D }
C {sky130_stdcells/inv_2.sym} 6350 -20660 0 0 {name=X_1302_ }
C {devices/lab_pin.sym} 6270 -20580 0 0 {name=p504 lab=_2276_/X }
C {devices/lab_pin.sym} 6270 -20540 0 0 {name=p505 lab=_2127_/Y }
C {devices/lab_pin.sym} 6270 -20500 0 0 {name=p506 lab=_2278_/X }
C {devices/lab_pin.sym} 6270 -20460 0 0 {name=p507 lab=_1705_/Y }
C {devices/lab_pin.sym} 6270 -20420 0 0 {name=p508 lab=_2280_/X }
C {devices/lab_pin.sym} 6430 -20500 0 1 {name=p509 lab=_2417_/D }
C {sky130_stdcells/o32ai_4.sym} 6350 -20500 0 0 {name=X_2282_ }
C {devices/lab_pin.sym} 6290 -20370 0 0 {name=p510 lab=_2017_/C }
C {devices/lab_pin.sym} 6290 -20330 0 0 {name=p511 lab=_1994_/Y }
C {devices/lab_pin.sym} 6290 -20290 0 0 {name=p512 lab=_2488_/Q }
C {devices/lab_pin.sym} 6290 -20250 0 0 {name=p513 lab=_2017_/D }
C {devices/lab_pin.sym} 6410 -20310 0 1 {name=p514 lab=_2008_/A }
C {sky130_stdcells/nand4_4.sym} 6350 -20310 0 0 {name=X_1997_ }
C {devices/lab_pin.sym} 6260 -20160 0 0 {name=p515 lab=_2550_/CLK }
C {devices/lab_pin.sym} 6260 -20140 0 0 {name=p516 lab=_2549_/D }
C {devices/lab_pin.sym} 6440 -20160 0 1 {name=p517 lab=_1897_/B }
C {sky130_stdcells/dfxtp_4.sym} 6350 -20150 0 0 {name=X_2549_ }
C {devices/lab_pin.sym} 6260 -20020 0 0 {name=p518 lab=_2618_/CLK }
C {devices/lab_pin.sym} 6260 -20000 0 0 {name=p519 lab=_1400_/Y }
C {devices/lab_pin.sym} 6440 -20020 0 1 {name=p520 lab=_2618_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -20010 0 0 {name=X_2618_ }
C {devices/lab_pin.sym} 6310 -19880 0 0 {name=p521 lab=clkbuf_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 6390 -19880 0 1 {name=p522 lab=clkbuf_2_1_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 6350 -19880 0 0 {name=Xclkbuf_1_0_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 6290 -19770 0 0 {name=p523 lab=_1635_/X }
C {devices/lab_pin.sym} 6290 -19730 0 0 {name=p524 lab=_1766_/B }
C {devices/lab_pin.sym} 6410 -19750 0 1 {name=p525 lab=_1851_/Y }
C {sky130_stdcells/nor2_4.sym} 6350 -19750 0 0 {name=X_1851_ }
C {devices/lab_pin.sym} 6290 -19630 0 0 {name=p526 lab=_1918_/A }
C {devices/lab_pin.sym} 6290 -19590 0 0 {name=p527 lab=_2538_/Q }
C {devices/lab_pin.sym} 6410 -19610 0 1 {name=p528 lab=_1920_/X }
C {sky130_stdcells/and2_4.sym} 6350 -19610 0 0 {name=X_1920_ }
C {devices/lab_pin.sym} 6270 -19500 0 0 {name=p529 lab=_1779_/Y }
C {devices/lab_pin.sym} 6270 -19460 0 0 {name=p530 lab=_1780_/Y }
C {devices/lab_pin.sym} 6270 -19420 0 0 {name=p531 lab=_1781_/X }
C {devices/lab_pin.sym} 6430 -19460 0 1 {name=p532 lab=_1782_/Y }
C {sky130_stdcells/a21oi_4.sym} 6350 -19460 0 0 {name=X_1782_ }
C {devices/lab_pin.sym} 6260 -19320 0 0 {name=p533 lab=_2408_/CLK }
C {devices/lab_pin.sym} 6260 -19300 0 0 {name=p534 lab=_2403_/D }
C {devices/lab_pin.sym} 6440 -19320 0 1 {name=p535 lab=_2089_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -19310 0 0 {name=X_2403_ }
C {devices/lab_pin.sym} 6290 -19200 0 0 {name=p536 lab=_1194_/B }
C {devices/lab_pin.sym} 6290 -19160 0 0 {name=p537 lab=_1216_/B }
C {devices/lab_pin.sym} 6290 -19120 0 0 {name=p538 lab=_2645_/Q }
C {devices/lab_pin.sym} 6410 -19160 0 1 {name=p539 lab=_1216_/Y }
C {sky130_stdcells/nand3_4.sym} 6350 -19160 0 0 {name=X_1216_ }
C {devices/lab_pin.sym} 6270 -19040 0 0 {name=p540 lab=_1529_/Y }
C {devices/lab_pin.sym} 6270 -19000 0 0 {name=p541 lab=_2333_/Y }
C {devices/lab_pin.sym} 6270 -18960 0 0 {name=p542 lab=_1781_/X }
C {devices/lab_pin.sym} 6430 -19000 0 1 {name=p543 lab=_2389_/D }
C {sky130_stdcells/a21oi_4.sym} 6350 -19000 0 0 {name=X_2334_ }
C {devices/lab_pin.sym} 6270 -18900 0 0 {name=p544 lab=_1420_/Y }
C {devices/lab_pin.sym} 6270 -18860 0 0 {name=p545 lab=_2262_/X }
C {devices/lab_pin.sym} 6270 -18820 0 0 {name=p546 lab=_2258_/X }
C {devices/lab_pin.sym} 6270 -18780 0 0 {name=p547 lab=_1622_/Y }
C {devices/lab_pin.sym} 6270 -18740 0 0 {name=p548 lab=_2264_/X }
C {devices/lab_pin.sym} 6430 -18820 0 1 {name=p549 lab=_2426_/D }
C {sky130_stdcells/o32ai_4.sym} 6350 -18820 0 0 {name=X_2265_ }
C {devices/lab_pin.sym} 6290 -18670 0 0 {name=p550 lab=_2151_/A }
C {devices/lab_pin.sym} 6290 -18630 0 0 {name=p551 lab=_1927_/A }
C {devices/lab_pin.sym} 6410 -18650 0 1 {name=p552 lab=_2196_/Y }
C {sky130_stdcells/nand2_4.sym} 6350 -18650 0 0 {name=X_2196_ }
C {devices/lab_pin.sym} 6310 -18520 0 0 {name=p553 lab=_2049_/Y }
C {devices/lab_pin.sym} 6390 -18520 0 1 {name=p554 lab=_2050_/Y }
C {sky130_stdcells/inv_2.sym} 6350 -18520 0 0 {name=X_2050_ }
C {devices/lab_pin.sym} 6310 -18400 0 0 {name=p555 lab=_1834_/A }
C {devices/lab_pin.sym} 6390 -18400 0 1 {name=p556 lab=_1834_/Y }
C {sky130_stdcells/inv_2.sym} 6350 -18400 0 0 {name=X_1834_ }
C {devices/lab_pin.sym} 6290 -18290 0 0 {name=p557 lab=_1901_/X }
C {devices/lab_pin.sym} 6290 -18250 0 0 {name=p558 lab=_1902_/Y }
C {devices/lab_pin.sym} 6410 -18270 0 1 {name=p559 lab=_1903_/Y }
C {sky130_stdcells/nor2_4.sym} 6350 -18270 0 0 {name=X_1903_ }
C {devices/lab_pin.sym} 6310 -18140 0 0 {name=p560 lab=_1765_/A }
C {devices/lab_pin.sym} 6390 -18140 0 1 {name=p561 lab=_1766_/B }
C {sky130_stdcells/inv_2.sym} 6350 -18140 0 0 {name=X_1765_ }
C {devices/lab_pin.sym} 6310 -18020 0 0 {name=p562 lab=_1696_/A }
C {devices/lab_pin.sym} 6390 -18020 0 1 {name=p563 lab=_1698_/A }
C {sky130_stdcells/buf_2.sym} 6350 -18020 0 0 {name=X_1696_ }
C {devices/lab_pin.sym} 6270 -17930 0 0 {name=p564 lab=_1751_/B }
C {devices/lab_pin.sym} 6270 -17890 0 0 {name=p565 lab=_2311_/X }
C {devices/lab_pin.sym} 6270 -17850 0 0 {name=p566 lab=_1490_/A }
C {devices/lab_pin.sym} 6270 -17810 0 0 {name=p567 lab=_2313_/X }
C {devices/lab_pin.sym} 6430 -17870 0 1 {name=p568 lab=_2399_/D }
C {sky130_stdcells/a2bb2o_4.sym} 6350 -17870 0 0 {name=X_2317_ }
C {devices/lab_pin.sym} 6290 -17740 0 0 {name=p569 lab=_2177_/Y }
C {devices/lab_pin.sym} 6290 -17700 0 0 {name=p570 lab=_2179_/B }
C {devices/lab_pin.sym} 6290 -17660 0 0 {name=p571 lab=_2179_/C }
C {devices/lab_pin.sym} 6410 -17700 0 1 {name=p572 lab=_2179_/Y }
C {sky130_stdcells/nand3_4.sym} 6350 -17700 0 0 {name=X_2179_ }
C {devices/lab_pin.sym} 6270 -17600 0 0 {name=p573 lab=_1583_/X }
C {devices/lab_pin.sym} 6270 -17560 0 0 {name=p574 lab=_1594_/X }
C {devices/lab_pin.sym} 6270 -17520 0 0 {name=p575 lab=_1600_/B }
C {devices/lab_pin.sym} 6270 -17480 0 0 {name=p576 lab=_1696_/A }
C {devices/lab_pin.sym} 6270 -17450 0 0 {name=p577 lab=_1736_/A }
C {devices/lab_pin.sym} 6430 -17520 0 1 {name=p578 lab=_2248_/X }
C {sky130_stdcells/a41o_4.sym} 6350 -17520 0 0 {name=X_2248_ }
C {devices/lab_pin.sym} 6270 -17380 0 0 {name=p579 lab=_1547_/X }
C {devices/lab_pin.sym} 6270 -17340 0 0 {name=p580 lab=_1548_/Y }
C {devices/lab_pin.sym} 6270 -17300 0 0 {name=p581 lab=_1549_/Y }
C {devices/lab_pin.sym} 6430 -17340 0 1 {name=p582 lab=_1550_/Y }
C {sky130_stdcells/o21ai_4.sym} 6350 -17340 0 0 {name=X_1550_ }
C {devices/lab_pin.sym} 6310 -17200 0 0 {name=p583 lab=_1436_/B }
C {devices/lab_pin.sym} 6390 -17200 0 1 {name=p584 lab=_1487_/A }
C {sky130_stdcells/buf_2.sym} 6350 -17200 0 0 {name=X_1481_ }
C {devices/lab_pin.sym} 6270 -17120 0 0 {name=p585 lab=_2043_/C }
C {devices/lab_pin.sym} 6270 -17080 0 0 {name=p586 lab=_2047_/A }
C {devices/lab_pin.sym} 6270 -17040 0 0 {name=p587 lab=_2017_/C }
C {devices/lab_pin.sym} 6270 -17000 0 0 {name=p588 lab=_2017_/D }
C {devices/lab_pin.sym} 6270 -16970 0 0 {name=p589 lab=_1275_/X }
C {devices/lab_pin.sym} 6430 -17040 0 1 {name=p590 lab=_2033_/Y }
C {sky130_stdcells/a41oi_4.sym} 6350 -17040 0 0 {name=X_2033_ }
C {devices/lab_pin.sym} 6290 -16910 0 0 {name=p591 lab=_2102_/A }
C {devices/lab_pin.sym} 6290 -16870 0 0 {name=p592 lab=_2103_/A }
C {devices/lab_pin.sym} 6290 -16830 0 0 {name=p593 lab=_2468_/Q }
C {devices/lab_pin.sym} 6290 -16790 0 0 {name=p594 lab=_2091_/Y }
C {devices/lab_pin.sym} 6410 -16850 0 1 {name=p595 lab=_2461_/D }
C {sky130_stdcells/nor4_4.sym} 6350 -16850 0 0 {name=X_2102_ }
C {devices/lab_pin.sym} 6270 -16720 0 0 {name=p596 lab=_2576_/Q }
C {devices/lab_pin.sym} 6270 -16680 0 0 {name=p597 lab=_1809_/X }
C {devices/lab_pin.sym} 6270 -16640 0 0 {name=p598 lab=_1816_/X }
C {devices/lab_pin.sym} 6430 -16680 0 1 {name=p599 lab=_1817_/X }
C {sky130_stdcells/o21a_4.sym} 6350 -16680 0 0 {name=X_1817_ }
C {devices/lab_pin.sym} 6270 -16560 0 0 {name=p600 lab=_1746_/Y }
C {devices/lab_pin.sym} 6270 -16520 0 0 {name=p601 lab=_1624_/X }
C {devices/lab_pin.sym} 6270 -16480 0 0 {name=p602 lab=_1747_/Y }
C {devices/lab_pin.sym} 6430 -16520 0 1 {name=p603 lab=_1748_/Y }
C {sky130_stdcells/o21ai_4.sym} 6350 -16520 0 0 {name=X_1748_ }
C {devices/lab_pin.sym} 6290 -16390 0 0 {name=p604 lab=_1566_/X }
C {devices/lab_pin.sym} 6290 -16350 0 0 {name=p605 lab=_1683_/A }
C {devices/lab_pin.sym} 6410 -16370 0 1 {name=p606 lab=_1679_/Y }
C {sky130_stdcells/nor2_4.sym} 6350 -16370 0 0 {name=X_1679_ }
C {devices/lab_pin.sym} 6260 -16240 0 0 {name=p607 lab=_2457_/CLK }
C {devices/lab_pin.sym} 6260 -16220 0 0 {name=p608 lab=_1193_/Y }
C {devices/lab_pin.sym} 6440 -16240 0 1 {name=p609 lab=_2353_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -16230 0 0 {name=X_2651_ }
C {devices/lab_pin.sym} 6290 -16120 0 0 {name=p610 lab=_1602_/A }
C {devices/lab_pin.sym} 6290 -16080 0 0 {name=p611 lab=_1600_/Y }
C {devices/lab_pin.sym} 6290 -16040 0 0 {name=p612 lab=_1602_/C }
C {devices/lab_pin.sym} 6410 -16080 0 1 {name=p613 lab=_1602_/Y }
C {sky130_stdcells/nand3_4.sym} 6350 -16080 0 0 {name=X_1602_ }
C {devices/lab_pin.sym} 6260 -15940 0 0 {name=p614 lab=_2581_/CLK }
C {devices/lab_pin.sym} 6260 -15920 0 0 {name=p615 lab=_2582_/D }
C {devices/lab_pin.sym} 6440 -15940 0 1 {name=p616 lab=_1503_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -15930 0 0 {name=X_2582_ }
C {devices/lab_pin.sym} 6290 -15820 0 0 {name=p617 lab=_1395_/A }
C {devices/lab_pin.sym} 6290 -15780 0 0 {name=p618 lab=_1379_/X }
C {devices/lab_pin.sym} 6290 -15740 0 0 {name=p619 lab=_1394_/Y }
C {devices/lab_pin.sym} 6410 -15780 0 1 {name=p620 lab=_1395_/Y }
C {sky130_stdcells/nor3_4.sym} 6350 -15780 0 0 {name=X_1395_ }
C {devices/lab_pin.sym} 6270 -15660 0 0 {name=p621 lab=_1438_/B }
C {devices/lab_pin.sym} 6270 -15620 0 0 {name=p622 lab=_1449_/B }
C {devices/lab_pin.sym} 6270 -15580 0 0 {name=p623 lab=_1213_/X }
C {devices/lab_pin.sym} 6430 -15620 0 1 {name=p624 lab=_1464_/Y }
C {sky130_stdcells/o21ai_4.sym} 6350 -15620 0 0 {name=X_1464_ }
C {devices/lab_pin.sym} 6310 -15480 0 0 {name=p625 lab=_2604_/Q }
C {devices/lab_pin.sym} 6390 -15480 0 1 {name=p626 lab=_1534_/A }
C {sky130_stdcells/inv_2.sym} 6350 -15480 0 0 {name=X_1533_ }
C {devices/lab_pin.sym} 6310 -15360 0 0 {name=p627 lab=_1987_/A }
C {devices/lab_pin.sym} 6390 -15360 0 1 {name=p628 lab=_2017_/B }
C {sky130_stdcells/buf_2.sym} 6350 -15360 0 0 {name=X_2016_ }
C {devices/lab_pin.sym} 6310 -15240 0 0 {name=p629 lab=_1178_/A }
C {devices/lab_pin.sym} 6390 -15240 0 1 {name=p630 lab=_1180_/Y }
C {sky130_stdcells/inv_2.sym} 6350 -15240 0 0 {name=X_1180_ }
C {devices/lab_pin.sym} 6260 -15120 0 0 {name=p631 lab=_2626_/CLK }
C {devices/lab_pin.sym} 6260 -15100 0 0 {name=p632 lab=_2634_/D }
C {devices/lab_pin.sym} 6440 -15120 0 1 {name=p633 lab=_1318_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -15110 0 0 {name=X_2634_ }
C {devices/lab_pin.sym} 6260 -14980 0 0 {name=p634 lab=_2562_/CLK }
C {devices/lab_pin.sym} 6260 -14960 0 0 {name=p635 lab=_2565_/D }
C {devices/lab_pin.sym} 6440 -14980 0 1 {name=p636 lab=_2565_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -14970 0 0 {name=X_2565_ }
C {devices/lab_pin.sym} 6270 -14860 0 0 {name=p637 lab=_1450_/X }
C {devices/lab_pin.sym} 6270 -14820 0 0 {name=p638 lab=_1512_/Y }
C {devices/lab_pin.sym} 6270 -14780 0 0 {name=p639 lab=_1500_/X }
C {devices/lab_pin.sym} 6430 -14820 0 1 {name=p640 lab=_1516_/X }
C {sky130_stdcells/a21o_4.sym} 6350 -14820 0 0 {name=X_1516_ }
C {devices/lab_pin.sym} 6260 -14680 0 0 {name=p641 lab=_2496_/CLK }
C {devices/lab_pin.sym} 6260 -14660 0 0 {name=p642 lab=_2496_/D }
C {devices/lab_pin.sym} 6440 -14680 0 1 {name=p643 lab=_2496_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -14670 0 0 {name=X_2496_ }
C {devices/lab_pin.sym} 6310 -14540 0 0 {name=p644 lab=_1378_/A }
C {devices/lab_pin.sym} 6390 -14540 0 1 {name=p645 lab=_2624_/D }
C {sky130_stdcells/inv_2.sym} 6350 -14540 0 0 {name=X_1378_ }
C {devices/lab_pin.sym} 6310 -14420 0 0 {name=p646 lab=_1446_/Y }
C {devices/lab_pin.sym} 6390 -14420 0 1 {name=p647 lab=_1448_/A }
C {sky130_stdcells/inv_2.sym} 6350 -14420 0 0 {name=X_1447_ }
C {devices/lab_pin.sym} 6270 -14320 0 0 {name=p648 lab=_2349_/A }
C {devices/lab_pin.sym} 6270 -14280 0 0 {name=p649 lab=_2348_/Y }
C {devices/lab_pin.sym} 6270 -14240 0 0 {name=p650 lab=_2349_/Y }
C {devices/lab_pin.sym} 6430 -14280 0 1 {name=p651 lab=MISO_toHost }
C {sky130_stdcells/a21oi_4.sym} 6350 -14280 0 0 {name=X_2350_ }
C {devices/lab_pin.sym} 6290 -14170 0 0 {name=p652 lab=_1232_/A }
C {devices/lab_pin.sym} 6290 -14130 0 0 {name=p653 lab=_2615_/Q }
C {devices/lab_pin.sym} 6290 -14090 0 0 {name=p654 lab=_1409_/B }
C {devices/lab_pin.sym} 6290 -14050 0 0 {name=p655 lab=_1232_/D }
C {devices/lab_pin.sym} 6410 -14110 0 1 {name=p656 lab=_1397_/C }
C {sky130_stdcells/nand4_4.sym} 6350 -14110 0 0 {name=X_1232_ }
C {devices/lab_pin.sym} 6290 -13980 0 0 {name=p657 lab=_1301_/A }
C {devices/lab_pin.sym} 6290 -13940 0 0 {name=p658 lab=_2006_/B }
C {devices/lab_pin.sym} 6290 -13900 0 0 {name=p659 lab=_1300_/Y }
C {devices/lab_pin.sym} 6410 -13940 0 1 {name=p660 lab=_1301_/Y }
C {sky130_stdcells/nand3_4.sym} 6350 -13940 0 0 {name=X_1301_ }
C {devices/lab_pin.sym} 6270 -13840 0 0 {name=p661 lab=_2276_/X }
C {devices/lab_pin.sym} 6270 -13800 0 0 {name=p662 lab=_2122_/Y }
C {devices/lab_pin.sym} 6270 -13760 0 0 {name=p663 lab=_2278_/X }
C {devices/lab_pin.sym} 6270 -13720 0 0 {name=p664 lab=_1620_/B }
C {devices/lab_pin.sym} 6270 -13680 0 0 {name=p665 lab=_2280_/X }
C {devices/lab_pin.sym} 6430 -13760 0 1 {name=p666 lab=_2281_/Y }
C {sky130_stdcells/o32ai_4.sym} 6350 -13760 0 0 {name=X_2281_ }
C {devices/lab_pin.sym} 6310 -13600 0 0 {name=p667 lab=_1995_/Y }
C {devices/lab_pin.sym} 6390 -13600 0 1 {name=p668 lab=_2017_/D }
C {sky130_stdcells/inv_2.sym} 6350 -13600 0 0 {name=X_1996_ }
C {devices/lab_pin.sym} 6260 -13480 0 0 {name=p669 lab=_2550_/CLK }
C {devices/lab_pin.sym} 6260 -13460 0 0 {name=p670 lab=_1894_/X }
C {devices/lab_pin.sym} 6440 -13480 0 1 {name=p671 lab=_1899_/B }
C {sky130_stdcells/dfxtp_4.sym} 6350 -13470 0 0 {name=X_2548_ }
C {devices/lab_pin.sym} 6260 -13340 0 0 {name=p672 lab=_2618_/CLK }
C {devices/lab_pin.sym} 6260 -13320 0 0 {name=p673 lab=_1404_/Y }
C {devices/lab_pin.sym} 6440 -13340 0 1 {name=p674 lab=_1231_/B }
C {sky130_stdcells/dfxtp_4.sym} 6350 -13330 0 0 {name=X_2617_ }
C {devices/lab_pin.sym} 6260 -13200 0 0 {name=p675 lab=_2483_/CLK }
C {devices/lab_pin.sym} 6260 -13180 0 0 {name=p676 lab=_2065_/X }
C {devices/lab_pin.sym} 6440 -13200 0 1 {name=p677 lab=_1993_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -13190 0 0 {name=X_2479_ }
C {devices/lab_pin.sym} 6310 -13060 0 0 {name=p678 lab=_1781_/A }
C {devices/lab_pin.sym} 6390 -13060 0 1 {name=p679 lab=_1781_/X }
C {sky130_stdcells/buf_2.sym} 6350 -13060 0 0 {name=X_1781_ }
C {devices/lab_pin.sym} 6270 -12960 0 0 {name=p680 lab=_1846_/X }
C {devices/lab_pin.sym} 6270 -12920 0 0 {name=p681 lab=_1849_/Y }
C {devices/lab_pin.sym} 6270 -12880 0 0 {name=p682 lab=_1628_/X }
C {devices/lab_pin.sym} 6430 -12920 0 1 {name=p683 lab=_1850_/X }
C {sky130_stdcells/a21o_4.sym} 6350 -12920 0 0 {name=X_1850_ }
C {devices/lab_pin.sym} 6290 -12790 0 0 {name=p684 lab=_1218_/B }
C {devices/lab_pin.sym} 6290 -12750 0 0 {name=p685 lab=_2333_/B }
C {devices/lab_pin.sym} 6410 -12770 0 1 {name=p686 lab=_2333_/Y }
C {sky130_stdcells/nand2_4.sym} 6350 -12770 0 0 {name=X_2333_ }
C {devices/lab_pin.sym} 6260 -12640 0 0 {name=p687 lab=_2445_/CLK }
C {devices/lab_pin.sym} 6260 -12620 0 0 {name=p688 lab=_2402_/D }
C {devices/lab_pin.sym} 6440 -12640 0 1 {name=p689 lab=_1636_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -12630 0 0 {name=X_2402_ }
C {devices/lab_pin.sym} 6270 -12520 0 0 {name=p690 lab=_1211_/Y }
C {devices/lab_pin.sym} 6270 -12480 0 0 {name=p691 lab=_2322_/A }
C {devices/lab_pin.sym} 6270 -12440 0 0 {name=p692 lab=_1214_/Y }
C {devices/lab_pin.sym} 6430 -12480 0 1 {name=p693 lab=_1215_/Y }
C {sky130_stdcells/a21oi_4.sym} 6350 -12480 0 0 {name=X_1215_ }
C {devices/lab_pin.sym} 6270 -12360 0 0 {name=p694 lab=_1534_/A }
C {devices/lab_pin.sym} 6270 -12320 0 0 {name=p695 lab=_2552_/Q }
C {devices/lab_pin.sym} 6270 -12280 0 0 {name=p696 lab=_2148_/X }
C {devices/lab_pin.sym} 6430 -12320 0 1 {name=p697 lab=_2195_/Y }
C {sky130_stdcells/o21ai_4.sym} 6350 -12320 0 0 {name=X_2195_ }
C {devices/lab_pin.sym} 6310 -12180 0 0 {name=p698 lab=_2263_/X }
C {devices/lab_pin.sym} 6390 -12180 0 1 {name=p699 lab=_2264_/X }
C {sky130_stdcells/buf_2.sym} 6350 -12180 0 0 {name=X_2264_ }
C {devices/lab_pin.sym} 6290 -12070 0 0 {name=p700 lab=_1979_/A }
C {devices/lab_pin.sym} 6290 -12030 0 0 {name=p701 lab=_2496_/Q }
C {devices/lab_pin.sym} 6410 -12050 0 1 {name=p702 lab=_1979_/X }
C {sky130_stdcells/or2_4.sym} 6350 -12050 0 0 {name=X_1979_ }
C {devices/lab_pin.sym} 6310 -11920 0 0 {name=p703 lab=_1902_/A }
C {devices/lab_pin.sym} 6390 -11920 0 1 {name=p704 lab=_1902_/Y }
C {sky130_stdcells/inv_2.sym} 6350 -11920 0 0 {name=X_1902_ }
C {devices/lab_pin.sym} 6290 -11810 0 0 {name=p705 lab=_1178_/A }
C {devices/lab_pin.sym} 6290 -11770 0 0 {name=p706 lab=_1735_/D }
C {devices/lab_pin.sym} 6410 -11790 0 1 {name=p707 lab=_1834_/A }
C {sky130_stdcells/nand2_4.sym} 6350 -11790 0 0 {name=X_1833_ }
C {devices/lab_pin.sym} 6310 -11660 0 0 {name=p708 lab=_1764_/A }
C {devices/lab_pin.sym} 6390 -11660 0 1 {name=p709 lab=_1764_/Y }
C {sky130_stdcells/inv_2.sym} 6350 -11660 0 0 {name=X_1764_ }
C {devices/lab_pin.sym} 6270 -11570 0 0 {name=p710 lab=_1766_/B }
C {devices/lab_pin.sym} 6270 -11530 0 0 {name=p711 lab=_2311_/X }
C {devices/lab_pin.sym} 6270 -11490 0 0 {name=p712 lab=_2268_/A }
C {devices/lab_pin.sym} 6270 -11450 0 0 {name=p713 lab=_2313_/X }
C {devices/lab_pin.sym} 6430 -11510 0 1 {name=p714 lab=_2316_/X }
C {sky130_stdcells/a2bb2o_4.sym} 6350 -11510 0 0 {name=X_2316_ }
C {devices/lab_pin.sym} 6310 -11360 0 0 {name=p715 lab=_1694_/X }
C {devices/lab_pin.sym} 6390 -11360 0 1 {name=p716 lab=_1696_/A }
C {sky130_stdcells/buf_2.sym} 6350 -11360 0 0 {name=X_1695_ }
C {devices/lab_pin.sym} 6310 -11240 0 0 {name=p717 lab=_2246_/Y }
C {devices/lab_pin.sym} 6390 -11240 0 1 {name=p718 lab=_2247_/X }
C {sky130_stdcells/buf_2.sym} 6350 -11240 0 0 {name=X_2247_ }
C {devices/lab_pin.sym} 6290 -11130 0 0 {name=p719 lab=_1944_/A }
C {devices/lab_pin.sym} 6290 -11090 0 0 {name=p720 lab=_1703_/A }
C {devices/lab_pin.sym} 6410 -11110 0 1 {name=p721 lab=_2179_/C }
C {sky130_stdcells/nand2_4.sym} 6350 -11110 0 0 {name=X_2178_ }
C {devices/lab_pin.sym} 6310 -10980 0 0 {name=p722 lab=clkbuf_4_9_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 6390 -10980 0 1 {name=p723 lab=_2388_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 6350 -10980 0 0 {name=Xclkbuf_4_9_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 6270 -10880 0 0 {name=p724 lab=_1476_/Y }
C {devices/lab_pin.sym} 6270 -10840 0 0 {name=p725 lab=_1478_/Y }
C {devices/lab_pin.sym} 6270 -10800 0 0 {name=p726 lab=_1479_/Y }
C {devices/lab_pin.sym} 6430 -10840 0 1 {name=p727 lab=_1480_/Y }
C {sky130_stdcells/a21oi_4.sym} 6350 -10840 0 0 {name=X_1480_ }
C {devices/lab_pin.sym} 6290 -10730 0 0 {name=p728 lab=_2029_/Y }
C {devices/lab_pin.sym} 6290 -10690 0 0 {name=p729 lab=_2030_/X }
C {devices/lab_pin.sym} 6290 -10650 0 0 {name=p730 lab=_2043_/C }
C {devices/lab_pin.sym} 6290 -10610 0 0 {name=p731 lab=_2017_/D }
C {devices/lab_pin.sym} 6410 -10670 0 1 {name=p732 lab=_2032_/X }
C {sky130_stdcells/and4_4.sym} 6350 -10670 0 0 {name=X_2032_ }
C {devices/lab_pin.sym} 6310 -10520 0 0 {name=p733 lab=_1221_/A }
C {devices/lab_pin.sym} 6390 -10520 0 1 {name=p734 lab=_2102_/A }
C {sky130_stdcells/buf_2.sym} 6350 -10520 0 0 {name=X_2101_ }
C {devices/lab_pin.sym} 6310 -10400 0 0 {name=p735 lab=_1678_/A }
C {devices/lab_pin.sym} 6390 -10400 0 1 {name=p736 lab=_1678_/Y }
C {sky130_stdcells/inv_2.sym} 6350 -10400 0 0 {name=X_1678_ }
C {devices/lab_pin.sym} 6270 -10300 0 0 {name=p737 lab=_2577_/Q }
C {devices/lab_pin.sym} 6270 -10260 0 0 {name=p738 lab=_1810_/X }
C {devices/lab_pin.sym} 6270 -10220 0 0 {name=p739 lab=_1813_/X }
C {devices/lab_pin.sym} 6430 -10260 0 1 {name=p740 lab=_1816_/X }
C {sky130_stdcells/o21a_4.sym} 6350 -10260 0 0 {name=X_1816_ }
C {devices/lab_pin.sym} 6270 -10140 0 0 {name=p741 lab=_1625_/X }
C {devices/lab_pin.sym} 6270 -10100 0 0 {name=p742 lab=_2431_/Q }
C {devices/lab_pin.sym} 6270 -10060 0 0 {name=p743 lab=_1708_/X }
C {devices/lab_pin.sym} 6430 -10100 0 1 {name=p744 lab=_1747_/Y }
C {sky130_stdcells/a21oi_4.sym} 6350 -10100 0 0 {name=X_1747_ }
C {devices/lab_pin.sym} 6260 -9960 0 0 {name=p745 lab=_2457_/CLK }
C {devices/lab_pin.sym} 6260 -9940 0 0 {name=p746 lab=_1197_/Y }
C {devices/lab_pin.sym} 6440 -9960 0 1 {name=p747 lab=_1182_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -9950 0 0 {name=X_2650_ }
C {devices/lab_pin.sym} 6260 -9820 0 0 {name=p748 lab=_2581_/CLK }
C {devices/lab_pin.sym} 6260 -9800 0 0 {name=p749 lab=_1805_/X }
C {devices/lab_pin.sym} 6440 -9820 0 1 {name=p750 lab=_1514_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -9810 0 0 {name=X_2581_ }
C {devices/lab_pin.sym} 6310 -9680 0 0 {name=p751 lab=_1555_/A }
C {devices/lab_pin.sym} 6390 -9680 0 1 {name=p752 lab=_1602_/C }
C {sky130_stdcells/buf_2.sym} 6350 -9680 0 0 {name=X_1601_ }
C {devices/lab_pin.sym} 6270 -9580 0 0 {name=p753 lab=_1420_/A }
C {devices/lab_pin.sym} 6270 -9540 0 0 {name=p754 lab=_1527_/Y }
C {devices/lab_pin.sym} 6270 -9500 0 0 {name=p755 lab=_1556_/A }
C {devices/lab_pin.sym} 6430 -9540 0 1 {name=p756 lab=_1532_/Y }
C {sky130_stdcells/a21oi_4.sym} 6350 -9540 0 0 {name=X_1532_ }
C {devices/lab_pin.sym} 6290 -9410 0 0 {name=p757 lab=_2619_/Q }
C {devices/lab_pin.sym} 6290 -9370 0 0 {name=p758 lab=_1383_/A }
C {devices/lab_pin.sym} 6410 -9390 0 1 {name=p759 lab=_1394_/Y }
C {sky130_stdcells/nor2_4.sym} 6350 -9390 0 0 {name=X_1394_ }
C {devices/lab_pin.sym} 6270 -9280 0 0 {name=p760 lab=_2266_/A }
C {devices/lab_pin.sym} 6270 -9240 0 0 {name=p761 lab=_2333_/B }
C {devices/lab_pin.sym} 6270 -9200 0 0 {name=p762 lab=_1462_/X }
C {devices/lab_pin.sym} 6430 -9240 0 1 {name=p763 lab=_1463_/Y }
C {sky130_stdcells/a21oi_4.sym} 6350 -9240 0 0 {name=X_1463_ }
C {devices/lab_pin.sym} 6290 -9120 0 0 {name=p764 lab=_2014_/X }
C {devices/lab_pin.sym} 6290 -9080 0 0 {name=p765 lab=_1986_/Y }
C {devices/lab_pin.sym} 6290 -9040 0 0 {name=p766 lab=_1994_/D }
C {devices/lab_pin.sym} 6410 -9080 0 1 {name=p767 lab=_2047_/A }
C {sky130_stdcells/nor3_4.sym} 6350 -9080 0 0 {name=X_2015_ }
C {devices/lab_pin.sym} 6310 -8940 0 0 {name=p768 lab=clkbuf_2_1_0_m1_clk_local/A }
C {devices/lab_pin.sym} 6390 -8940 0 1 {name=p769 lab=clkbuf_3_3_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 6350 -8940 0 0 {name=Xclkbuf_2_1_0_m1_clk_local }
C {devices/lab_pin.sym} 6310 -8820 0 0 {name=p770 lab=clkbuf_2_1_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 6390 -8820 0 1 {name=p771 lab=clkbuf_2_0_0_addressalyzerBlock.SPI_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 6350 -8820 0 0 {name=Xclkbuf_2_0_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 6260 -8700 0 0 {name=p772 lab=_2496_/CLK }
C {devices/lab_pin.sym} 6260 -8680 0 0 {name=p773 lab=_2495_/D }
C {devices/lab_pin.sym} 6440 -8700 0 1 {name=p774 lab=_1979_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -8690 0 0 {name=X_2495_ }
C {devices/lab_pin.sym} 6260 -8560 0 0 {name=p775 lab=_2626_/CLK }
C {devices/lab_pin.sym} 6260 -8540 0 0 {name=p776 lab=_2633_/D }
C {devices/lab_pin.sym} 6440 -8560 0 1 {name=p777 lab=_1244_/B }
C {sky130_stdcells/dfxtp_4.sym} 6350 -8550 0 0 {name=X_2633_ }
C {devices/lab_pin.sym} 6260 -8420 0 0 {name=p778 lab=_2557_/CLK }
C {devices/lab_pin.sym} 6260 -8400 0 0 {name=p779 lab=_2564_/D }
C {devices/lab_pin.sym} 6440 -8420 0 1 {name=p780 lab=_2564_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -8410 0 0 {name=X_2564_ }
C {devices/lab_pin.sym} 6270 -8300 0 0 {name=p781 lab=_1514_/X }
C {devices/lab_pin.sym} 6270 -8260 0 0 {name=p782 lab=_1460_/X }
C {devices/lab_pin.sym} 6270 -8220 0 0 {name=p783 lab=_1462_/X }
C {devices/lab_pin.sym} 6430 -8260 0 1 {name=p784 lab=_1515_/Y }
C {sky130_stdcells/a21oi_4.sym} 6350 -8260 0 0 {name=X_1515_ }
C {devices/lab_pin.sym} 6290 -8130 0 0 {name=p785 lab=_1375_/X }
C {devices/lab_pin.sym} 6290 -8090 0 0 {name=p786 lab=_1376_/Y }
C {devices/lab_pin.sym} 6410 -8110 0 1 {name=p787 lab=_1378_/A }
C {sky130_stdcells/nand2_4.sym} 6350 -8110 0 0 {name=X_1377_ }
C {devices/lab_pin.sym} 6290 -8000 0 0 {name=p788 lab=_1442_/X }
C {devices/lab_pin.sym} 6290 -7960 0 0 {name=p789 lab=_1445_/A }
C {devices/lab_pin.sym} 6290 -7920 0 0 {name=p790 lab=_1545_/A }
C {devices/lab_pin.sym} 6410 -7960 0 1 {name=p791 lab=_1446_/Y }
C {sky130_stdcells/nand3_4.sym} 6350 -7960 0 0 {name=X_1446_ }
C {devices/lab_pin.sym} 6290 -7830 0 0 {name=p792 lab=_2618_/Q }
C {devices/lab_pin.sym} 6290 -7790 0 0 {name=p793 lab=_1231_/B }
C {devices/lab_pin.sym} 6410 -7810 0 1 {name=p794 lab=_1233_/C }
C {sky130_stdcells/nand2_4.sym} 6350 -7810 0 0 {name=X_1231_ }
C {devices/lab_pin.sym} 6290 -7690 0 0 {name=p795 lab=_1260_/Y }
C {devices/lab_pin.sym} 6290 -7650 0 0 {name=p796 lab=_1300_/B }
C {devices/lab_pin.sym} 6410 -7670 0 1 {name=p797 lab=_1300_/Y }
C {sky130_stdcells/nand2_4.sym} 6350 -7670 0 0 {name=X_1300_ }
C {devices/lab_pin.sym} 6310 -7540 0 0 {name=p798 lab=_2279_/X }
C {devices/lab_pin.sym} 6390 -7540 0 1 {name=p799 lab=_2280_/X }
C {sky130_stdcells/buf_2.sym} 6350 -7540 0 0 {name=X_2280_ }
C {devices/lab_pin.sym} 6290 -7430 0 0 {name=p800 lab=_2043_/D }
C {devices/lab_pin.sym} 6290 -7390 0 0 {name=p801 lab=_2037_/D }
C {devices/lab_pin.sym} 6410 -7410 0 1 {name=p802 lab=_1995_/Y }
C {sky130_stdcells/nand2_4.sym} 6350 -7410 0 0 {name=X_1995_ }
C {devices/lab_pin.sym} 6260 -7280 0 0 {name=p803 lab=_2618_/CLK }
C {devices/lab_pin.sym} 6260 -7260 0 0 {name=p804 lab=_1408_/Y }
C {devices/lab_pin.sym} 6440 -7280 0 1 {name=p805 lab=_2616_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -7270 0 0 {name=X_2616_ }
C {devices/lab_pin.sym} 6260 -7140 0 0 {name=p806 lab=_2550_/CLK }
C {devices/lab_pin.sym} 6260 -7120 0 0 {name=p807 lab=_2547_/D }
C {devices/lab_pin.sym} 6440 -7140 0 1 {name=p808 lab=_2547_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -7130 0 0 {name=X_2547_ }
C {devices/lab_pin.sym} 6260 -7000 0 0 {name=p809 lab=_2483_/CLK }
C {devices/lab_pin.sym} 6260 -6980 0 0 {name=p810 lab=_2478_/D }
C {devices/lab_pin.sym} 6440 -7000 0 1 {name=p811 lab=_2478_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -6990 0 0 {name=X_2478_ }
C {devices/lab_pin.sym} 6290 -6870 0 0 {name=p812 lab=_1424_/Y }
C {devices/lab_pin.sym} 6290 -6830 0 0 {name=p813 lab=_1428_/Y }
C {devices/lab_pin.sym} 6410 -6850 0 1 {name=p814 lab=_1429_/Y }
C {sky130_stdcells/nor2_4.sym} 6350 -6850 0 0 {name=X_1429_ }
C {devices/lab_pin.sym} 6310 -6720 0 0 {name=p815 lab=clkbuf_4_5_0_m1_clk_local/A }
C {devices/lab_pin.sym} 6390 -6720 0 1 {name=p816 lab=_2477_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 6350 -6720 0 0 {name=Xclkbuf_4_4_0_m1_clk_local }
C {devices/lab_pin.sym} 6290 -6610 0 0 {name=p817 lab=_1678_/Y }
C {devices/lab_pin.sym} 6290 -6570 0 0 {name=p818 lab=_1780_/B }
C {devices/lab_pin.sym} 6410 -6590 0 1 {name=p819 lab=_1780_/Y }
C {sky130_stdcells/nand2_4.sym} 6350 -6590 0 0 {name=X_1780_ }
C {devices/lab_pin.sym} 6270 -6490 0 0 {name=p820 lab=_1218_/B }
C {devices/lab_pin.sym} 6270 -6450 0 0 {name=p821 lab=_2392_/Q }
C {devices/lab_pin.sym} 6270 -6410 0 0 {name=p822 lab=_2102_/A }
C {devices/lab_pin.sym} 6270 -6370 0 0 {name=p823 lab=_1729_/Y }
C {devices/lab_pin.sym} 6430 -6430 0 1 {name=p824 lab=_2391_/D }
C {sky130_stdcells/a211o_4.sym} 6350 -6430 0 0 {name=X_2332_ }
C {devices/lab_pin.sym} 6260 -6280 0 0 {name=p825 lab=_2410_/CLK }
C {devices/lab_pin.sym} 6260 -6260 0 0 {name=p826 lab=_2401_/D }
C {devices/lab_pin.sym} 6440 -6280 0 1 {name=p827 lab=_1768_/B }
C {sky130_stdcells/dfxtp_4.sym} 6350 -6270 0 0 {name=X_2401_ }
C {devices/lab_pin.sym} 6270 -6160 0 0 {name=p828 lab=_2436_/Q }
C {devices/lab_pin.sym} 6270 -6120 0 0 {name=p829 lab=_1187_/A }
C {devices/lab_pin.sym} 6270 -6080 0 0 {name=p830 lab=_1213_/X }
C {devices/lab_pin.sym} 6430 -6120 0 1 {name=p831 lab=_1214_/Y }
C {sky130_stdcells/o21ai_4.sym} 6350 -6120 0 0 {name=X_1214_ }
C {devices/lab_pin.sym} 6270 -6020 0 0 {name=p832 lab=_1409_/B }
C {devices/lab_pin.sym} 6270 -5980 0 0 {name=p833 lab=_1571_/A }
C {devices/lab_pin.sym} 6270 -5940 0 0 {name=p834 lab=_1568_/A }
C {devices/lab_pin.sym} 6270 -5900 0 0 {name=p835 lab=_1660_/A }
C {devices/lab_pin.sym} 6270 -5860 0 0 {name=p836 lab=_2146_/Y }
C {devices/lab_pin.sym} 6430 -5940 0 1 {name=p837 lab=_2194_/Y }
C {sky130_stdcells/o41ai_4.sym} 6350 -5940 0 0 {name=X_2194_ }
C {devices/lab_pin.sym} 6270 -5820 0 0 {name=p838 lab=_1583_/X }
C {devices/lab_pin.sym} 6270 -5780 0 0 {name=p839 lab=_1594_/X }
C {devices/lab_pin.sym} 6270 -5740 0 0 {name=p840 lab=_1669_/B }
C {devices/lab_pin.sym} 6270 -5700 0 0 {name=p841 lab=_1694_/X }
C {devices/lab_pin.sym} 6270 -5670 0 0 {name=p842 lab=_1736_/A }
C {devices/lab_pin.sym} 6430 -5740 0 1 {name=p843 lab=_2263_/X }
C {sky130_stdcells/a41o_4.sym} 6350 -5740 0 0 {name=X_2263_ }
C {devices/lab_pin.sym} 6290 -5600 0 0 {name=p844 lab=_1980_/A }
C {devices/lab_pin.sym} 6290 -5560 0 0 {name=p845 lab=_1978_/B }
C {devices/lab_pin.sym} 6290 -5520 0 0 {name=p846 lab=_1978_/C }
C {devices/lab_pin.sym} 6410 -5560 0 1 {name=p847 lab=_1978_/X }
C {sky130_stdcells/and3_4.sym} 6350 -5560 0 0 {name=X_1978_ }
C {devices/lab_pin.sym} 6270 -5440 0 0 {name=p848 lab=_1829_/Y }
C {devices/lab_pin.sym} 6270 -5400 0 0 {name=p849 lab=_1830_/Y }
C {devices/lab_pin.sym} 6270 -5360 0 0 {name=p850 lab=_1831_/Y }
C {devices/lab_pin.sym} 6430 -5400 0 1 {name=p851 lab=_2571_/D }
C {sky130_stdcells/a21oi_4.sym} 6350 -5400 0 0 {name=X_1832_ }
C {devices/lab_pin.sym} 6310 -5260 0 0 {name=p852 lab=_2063_/A }
C {devices/lab_pin.sym} 6390 -5260 0 1 {name=p853 lab=_1901_/X }
C {sky130_stdcells/buf_2.sym} 6350 -5260 0 0 {name=X_1901_ }
C {devices/lab_pin.sym} 6270 -5160 0 0 {name=p854 lab=_1740_/Y }
C {devices/lab_pin.sym} 6270 -5120 0 0 {name=p855 lab=_1760_/Y }
C {devices/lab_pin.sym} 6270 -5080 0 0 {name=p856 lab=_1762_/Y }
C {devices/lab_pin.sym} 6430 -5120 0 1 {name=p857 lab=_2590_/D }
C {sky130_stdcells/o21ai_4.sym} 6350 -5120 0 0 {name=X_1763_ }
C {devices/lab_pin.sym} 6310 -4980 0 0 {name=p858 lab=_2594_/Q }
C {devices/lab_pin.sym} 6390 -4980 0 1 {name=p859 lab=_1694_/X }
C {sky130_stdcells/buf_2.sym} 6350 -4980 0 0 {name=X_1694_ }
C {devices/lab_pin.sym} 6270 -4890 0 0 {name=p860 lab=_1713_/Y }
C {devices/lab_pin.sym} 6270 -4850 0 0 {name=p861 lab=_2311_/X }
C {devices/lab_pin.sym} 6270 -4810 0 0 {name=p862 lab=_2266_/A }
C {devices/lab_pin.sym} 6270 -4770 0 0 {name=p863 lab=_2313_/X }
C {devices/lab_pin.sym} 6430 -4830 0 1 {name=p864 lab=_2401_/D }
C {sky130_stdcells/a2bb2o_4.sym} 6350 -4830 0 0 {name=X_2315_ }
C {devices/lab_pin.sym} 6310 -4680 0 0 {name=p865 lab=_2246_/A }
C {devices/lab_pin.sym} 6390 -4680 0 1 {name=p866 lab=_2246_/Y }
C {sky130_stdcells/inv_2.sym} 6350 -4680 0 0 {name=X_2246_ }
C {devices/lab_pin.sym} 6290 -4570 0 0 {name=p867 lab=_2151_/A }
C {devices/lab_pin.sym} 6290 -4530 0 0 {name=p868 lab=_2177_/B }
C {devices/lab_pin.sym} 6410 -4550 0 1 {name=p869 lab=_2177_/Y }
C {sky130_stdcells/nand2_4.sym} 6350 -4550 0 0 {name=X_2177_ }
C {devices/lab_pin.sym} 6310 -4420 0 0 {name=p870 lab=clkbuf_3_7_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 6390 -4420 0 1 {name=p871 lab=_2570_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 6350 -4420 0 0 {name=Xclkbuf_4_14_0_addressalyzerBlock.SPI_CLK }
C {sky130_stdcells/decap_3.sym} 6350 -4270 0 0 {name=XPHY_120 }
C {devices/lab_pin.sym} 6290 -4140 0 0 {name=p872 lab=_1781_/X }
C {devices/lab_pin.sym} 6290 -4100 0 0 {name=p873 lab=_2099_/C }
C {devices/lab_pin.sym} 6290 -4060 0 0 {name=p874 lab=_2098_/Y }
C {devices/lab_pin.sym} 6410 -4100 0 1 {name=p875 lab=_2462_/D }
C {sky130_stdcells/nor3_4.sym} 6350 -4100 0 0 {name=X_2100_ }
C {devices/lab_pin.sym} 6310 -3960 0 0 {name=p876 lab=_2017_/B }
C {devices/lab_pin.sym} 6390 -3960 0 1 {name=p877 lab=_2043_/C }
C {sky130_stdcells/buf_2.sym} 6350 -3960 0 0 {name=X_2031_ }
C {sky130_stdcells/decap_3.sym} 6350 -3810 0 0 {name=XPHY_0 }
C {devices/lab_pin.sym} 6270 -3680 0 0 {name=p878 lab=_2577_/Q }
C {devices/lab_pin.sym} 6270 -3640 0 0 {name=p879 lab=_1809_/X }
C {devices/lab_pin.sym} 6270 -3600 0 0 {name=p880 lab=_1814_/X }
C {devices/lab_pin.sym} 6430 -3640 0 1 {name=p881 lab=_2578_/D }
C {sky130_stdcells/o21a_4.sym} 6350 -3640 0 0 {name=X_1815_ }
C {devices/lab_pin.sym} 6290 -3510 0 0 {name=p882 lab=_1674_/Y }
C {devices/lab_pin.sym} 6290 -3470 0 0 {name=p883 lab=_1676_/Y }
C {devices/lab_pin.sym} 6410 -3490 0 1 {name=p884 lab=_2596_/D }
C {sky130_stdcells/nand2_4.sym} 6350 -3490 0 0 {name=X_1677_ }
C {devices/lab_pin.sym} 6310 -3360 0 0 {name=p885 lab=_1746_/A }
C {devices/lab_pin.sym} 6390 -3360 0 1 {name=p886 lab=_1746_/Y }
C {sky130_stdcells/inv_2.sym} 6350 -3360 0 0 {name=X_1746_ }
C {devices/lab_pin.sym} 6270 -3260 0 0 {name=p887 lab=_1645_/A }
C {devices/lab_pin.sym} 6270 -3220 0 0 {name=p888 lab=_1333_/A }
C {devices/lab_pin.sym} 6270 -3180 0 0 {name=p889 lab=_1612_/A }
C {devices/lab_pin.sym} 6430 -3220 0 1 {name=p890 lab=_2229_/Y }
C {sky130_stdcells/a21oi_4.sym} 6350 -3220 0 0 {name=X_2229_ }
C {devices/lab_pin.sym} 6310 -3080 0 0 {name=p891 lab=_1530_/Y }
C {devices/lab_pin.sym} 6390 -3080 0 1 {name=p892 lab=_1556_/A }
C {sky130_stdcells/buf_2.sym} 6350 -3080 0 0 {name=X_1531_ }
C {devices/lab_pin.sym} 6290 -2970 0 0 {name=p893 lab=_1549_/A }
C {devices/lab_pin.sym} 6290 -2930 0 0 {name=p894 lab=_1600_/B }
C {devices/lab_pin.sym} 6410 -2950 0 1 {name=p895 lab=_1600_/Y }
C {sky130_stdcells/nand2_4.sym} 6350 -2950 0 0 {name=X_1600_ }
C {devices/lab_pin.sym} 6310 -2820 0 0 {name=p896 lab=_1450_/X }
C {devices/lab_pin.sym} 6390 -2820 0 1 {name=p897 lab=_1462_/X }
C {sky130_stdcells/buf_2.sym} 6350 -2820 0 0 {name=X_1462_ }
C {devices/lab_pin.sym} 6260 -2700 0 0 {name=p898 lab=_2581_/CLK }
C {devices/lab_pin.sym} 6260 -2680 0 0 {name=p899 lab=_1807_/X }
C {devices/lab_pin.sym} 6440 -2700 0 1 {name=p900 lab=_1520_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -2690 0 0 {name=X_2580_ }
C {devices/lab_pin.sym} 6270 -2580 0 0 {name=p901 lab=_1385_/D }
C {devices/lab_pin.sym} 6270 -2540 0 0 {name=p902 lab=_1379_/X }
C {devices/lab_pin.sym} 6270 -2500 0 0 {name=p903 lab=_1392_/Y }
C {devices/lab_pin.sym} 6430 -2540 0 1 {name=p904 lab=_2620_/D }
C {sky130_stdcells/o21a_4.sym} 6350 -2540 0 0 {name=X_1393_ }
C {devices/lab_pin.sym} 6310 -2400 0 0 {name=p905 lab=_1985_/Y }
C {devices/lab_pin.sym} 6390 -2400 0 1 {name=p906 lab=_2014_/X }
C {sky130_stdcells/buf_2.sym} 6350 -2400 0 0 {name=X_2014_ }
C {devices/lab_pin.sym} 6290 -2300 0 0 {name=p907 lab=_2386_/Q }
C {devices/lab_pin.sym} 6290 -2260 0 0 {name=p908 lab=_1566_/A }
C {devices/lab_pin.sym} 6290 -2220 0 0 {name=p909 lab=_1689_/Y }
C {devices/lab_pin.sym} 6410 -2260 0 1 {name=p910 lab=_1729_/Y }
C {sky130_stdcells/nor3_4.sym} 6350 -2260 0 0 {name=X_1729_ }
C {devices/lab_pin.sym} 6260 -2120 0 0 {name=p911 lab=_2626_/CLK }
C {devices/lab_pin.sym} 6260 -2100 0 0 {name=p912 lab=_1337_/Y }
C {devices/lab_pin.sym} 6440 -2120 0 1 {name=p913 lab=_1335_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -2110 0 0 {name=X_2632_ }
C {devices/lab_pin.sym} 6260 -1980 0 0 {name=p914 lab=_2562_/CLK }
C {devices/lab_pin.sym} 6260 -1960 0 0 {name=p915 lab=_1876_/X }
C {devices/lab_pin.sym} 6440 -1980 0 1 {name=p916 lab=_2563_/Q }
C {sky130_stdcells/dfxtp_4.sym} 6350 -1970 0 0 {name=X_2563_ }
C {devices/lab_pin.sym} 6290 -1870 0 0 {name=p917 lab=_1445_/A }
C {devices/lab_pin.sym} 6290 -1830 0 0 {name=p918 lab=_1434_/Y }
C {devices/lab_pin.sym} 6290 -1790 0 0 {name=p919 lab=_1444_/Y }
C {devices/lab_pin.sym} 6290 -1750 0 0 {name=p920 lab=_1445_/D }
C {devices/lab_pin.sym} 6410 -1810 0 1 {name=p921 lab=_1545_/A }
C {sky130_stdcells/nand4_4.sym} 6350 -1810 0 0 {name=X_1445_ }
C {devices/lab_pin.sym} 6260 -1660 0 0 {name=p922 lab=_2388_/CLK }
C {devices/lab_pin.sym} 6260 -1640 0 0 {name=p923 lab=_1983_/Y }
C {devices/lab_pin.sym} 6440 -1660 0 1 {name=p924 lab=_1528_/A }
C {sky130_stdcells/dfxtp_4.sym} 6350 -1650 0 0 {name=X_2494_ }
C {devices/lab_pin.sym} 1650 -21920 0 0 {name=p925 lab=_1514_/A }
C {devices/lab_pin.sym} 1730 -21920 0 1 {name=p926 lab=_1514_/X }
C {sky130_stdcells/buf_2.sym} 1690 -21920 0 0 {name=X_1514_ }
C {devices/lab_pin.sym} 1630 -21820 0 0 {name=p927 lab=_1366_/X }
C {devices/lab_pin.sym} 1630 -21780 0 0 {name=p928 lab=_1236_/A }
C {devices/lab_pin.sym} 1630 -21740 0 0 {name=p929 lab=_1373_/B }
C {devices/lab_pin.sym} 1750 -21780 0 1 {name=p930 lab=_1376_/Y }
C {sky130_stdcells/nand3_4.sym} 1690 -21780 0 0 {name=X_1376_ }
C {devices/lab_pin.sym} 1650 -21640 0 0 {name=p931 lab=clkbuf_3_6_0_m1_clk_local/X }
C {devices/lab_pin.sym} 1730 -21640 0 1 {name=p932 lab=_2367_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 1690 -21640 0 0 {name=Xclkbuf_4_12_0_m1_clk_local }
C {devices/lab_pin.sym} 1650 -21520 0 0 {name=p933 lab=_2616_/Q }
C {devices/lab_pin.sym} 1730 -21520 0 1 {name=p934 lab=_1397_/B }
C {sky130_stdcells/inv_2.sym} 1690 -21520 0 0 {name=X_1230_ }
C {devices/lab_pin.sym} 1630 -21430 0 0 {name=p935 lab=_1985_/Y }
C {devices/lab_pin.sym} 1630 -21390 0 0 {name=p936 lab=_1986_/Y }
C {devices/lab_pin.sym} 1630 -21350 0 0 {name=p937 lab=_1994_/C }
C {devices/lab_pin.sym} 1630 -21310 0 0 {name=p938 lab=_1994_/D }
C {devices/lab_pin.sym} 1750 -21370 0 1 {name=p939 lab=_1994_/Y }
C {sky130_stdcells/nor4_4.sym} 1690 -21370 0 0 {name=X_1994_ }
C {devices/lab_pin.sym} 1600 -21220 0 0 {name=p940 lab=_2618_/CLK }
C {devices/lab_pin.sym} 1600 -21200 0 0 {name=p941 lab=_1412_/X }
C {devices/lab_pin.sym} 1780 -21220 0 1 {name=p942 lab=_2615_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -21210 0 0 {name=X_2615_ }
C {devices/lab_pin.sym} 1600 -21080 0 0 {name=p943 lab=_2550_/CLK }
C {devices/lab_pin.sym} 1600 -21060 0 0 {name=p944 lab=_2546_/D }
C {devices/lab_pin.sym} 1780 -21080 0 1 {name=p945 lab=_2546_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -21070 0 0 {name=X_2546_ }
C {devices/lab_pin.sym} 1600 -20940 0 0 {name=p946 lab=_2477_/CLK }
C {devices/lab_pin.sym} 1600 -20920 0 0 {name=p947 lab=_2070_/Y }
C {devices/lab_pin.sym} 1780 -20940 0 1 {name=p948 lab=_2477_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -20930 0 0 {name=X_2477_ }
C {devices/lab_pin.sym} 1630 -20830 0 0 {name=p949 lab=_1570_/A }
C {devices/lab_pin.sym} 1630 -20790 0 0 {name=p950 lab=_1428_/B }
C {devices/lab_pin.sym} 1630 -20750 0 0 {name=p951 lab=_1428_/C }
C {devices/lab_pin.sym} 1630 -20710 0 0 {name=p952 lab=_1428_/D }
C {devices/lab_pin.sym} 1750 -20770 0 1 {name=p953 lab=_1428_/Y }
C {sky130_stdcells/nand4_4.sym} 1690 -20770 0 0 {name=X_1428_ }
C {devices/lab_pin.sym} 1650 -20620 0 0 {name=p954 lab=_1358_/Y }
C {devices/lab_pin.sym} 1730 -20620 0 1 {name=p955 lab=_2627_/D }
C {sky130_stdcells/inv_2.sym} 1690 -20620 0 0 {name=X_1359_ }
C {devices/lab_pin.sym} 1600 -20500 0 0 {name=p956 lab=_2606_/CLK }
C {devices/lab_pin.sym} 1600 -20480 0 0 {name=p957 lab=_2316_/X }
C {devices/lab_pin.sym} 1780 -20500 0 1 {name=p958 lab=_1765_/A }
C {sky130_stdcells/dfxtp_4.sym} 1690 -20490 0 0 {name=X_2400_ }
C {devices/lab_pin.sym} 1650 -20360 0 0 {name=p959 lab=_2096_/A }
C {devices/lab_pin.sym} 1730 -20360 0 1 {name=p960 lab=_1213_/X }
C {sky130_stdcells/buf_2.sym} 1690 -20360 0 0 {name=X_1213_ }
C {devices/lab_pin.sym} 1630 -20250 0 0 {name=p961 lab=_1222_/X }
C {devices/lab_pin.sym} 1630 -20210 0 0 {name=p962 lab=_2330_/Y }
C {devices/lab_pin.sym} 1750 -20230 0 1 {name=p963 lab=_2390_/D }
C {sky130_stdcells/nor2_4.sym} 1690 -20230 0 0 {name=X_2331_ }
C {devices/lab_pin.sym} 1650 -20100 0 0 {name=p964 lab=_1649_/B }
C {devices/lab_pin.sym} 1730 -20100 0 1 {name=p965 lab=_2262_/X }
C {sky130_stdcells/buf_2.sym} 1690 -20100 0 0 {name=X_2262_ }
C {devices/lab_pin.sym} 1610 -20000 0 0 {name=p966 lab=_1726_/A }
C {devices/lab_pin.sym} 1610 -19960 0 0 {name=p967 lab=_2191_/Y }
C {devices/lab_pin.sym} 1610 -19920 0 0 {name=p968 lab=_2192_/Y }
C {devices/lab_pin.sym} 1770 -19960 0 1 {name=p969 lab=_2193_/Y }
C {sky130_stdcells/o21ai_4.sym} 1690 -19960 0 0 {name=X_2193_ }
C {devices/lab_pin.sym} 1610 -19840 0 0 {name=p970 lab=_1979_/A }
C {devices/lab_pin.sym} 1610 -19800 0 0 {name=p971 lab=_2496_/Q }
C {devices/lab_pin.sym} 1610 -19760 0 0 {name=p972 lab=_2497_/Q }
C {devices/lab_pin.sym} 1770 -19800 0 1 {name=p973 lab=_1978_/C }
C {sky130_stdcells/a21o_4.sym} 1690 -19800 0 0 {name=X_1977_ }
C {devices/lab_pin.sym} 1600 -19660 0 0 {name=p974 lab=_2528_/CLK }
C {devices/lab_pin.sym} 1600 -19640 0 0 {name=p975 lab=_2529_/D }
C {devices/lab_pin.sym} 1780 -19660 0 1 {name=p976 lab=_2529_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -19650 0 0 {name=X_2529_ }
C {devices/lab_pin.sym} 1630 -19530 0 0 {name=p977 lab=_1900_/A }
C {devices/lab_pin.sym} 1630 -19490 0 0 {name=p978 lab=_2547_/Q }
C {devices/lab_pin.sym} 1750 -19510 0 1 {name=p979 lab=_2543_/D }
C {sky130_stdcells/and2_4.sym} 1690 -19510 0 0 {name=X_1900_ }
C {devices/lab_pin.sym} 1630 -19390 0 0 {name=p980 lab=_1831_/A }
C {devices/lab_pin.sym} 1630 -19350 0 0 {name=p981 lab=_1831_/B }
C {devices/lab_pin.sym} 1750 -19370 0 1 {name=p982 lab=_1831_/Y }
C {sky130_stdcells/nand2_4.sym} 1690 -19370 0 0 {name=X_1831_ }
C {devices/lab_pin.sym} 1630 -19250 0 0 {name=p983 lab=_1762_/A }
C {devices/lab_pin.sym} 1630 -19210 0 0 {name=p984 lab=_1762_/B }
C {devices/lab_pin.sym} 1750 -19230 0 1 {name=p985 lab=_1762_/Y }
C {sky130_stdcells/nand2_4.sym} 1690 -19230 0 0 {name=X_1762_ }
C {devices/lab_pin.sym} 1610 -19120 0 0 {name=p986 lab=_1688_/Y }
C {devices/lab_pin.sym} 1610 -19080 0 0 {name=p987 lab=_1690_/Y }
C {devices/lab_pin.sym} 1610 -19040 0 0 {name=p988 lab=_1692_/X }
C {devices/lab_pin.sym} 1770 -19080 0 1 {name=p989 lab=_1693_/Y }
C {sky130_stdcells/o21ai_4.sym} 1690 -19080 0 0 {name=X_1693_ }
C {devices/lab_pin.sym} 1630 -18960 0 0 {name=p990 lab=_1219_/X }
C {devices/lab_pin.sym} 1630 -18920 0 0 {name=p991 lab=_2245_/B }
C {devices/lab_pin.sym} 1630 -18880 0 0 {name=p992 lab=_1691_/Y }
C {devices/lab_pin.sym} 1750 -18920 0 1 {name=p993 lab=_2246_/A }
C {sky130_stdcells/nor3_4.sym} 1690 -18920 0 0 {name=X_2245_ }
C {devices/lab_pin.sym} 1610 -18810 0 0 {name=p994 lab=_1637_/B }
C {devices/lab_pin.sym} 1610 -18770 0 0 {name=p995 lab=_2311_/X }
C {devices/lab_pin.sym} 1610 -18730 0 0 {name=p996 lab=_1420_/A }
C {devices/lab_pin.sym} 1610 -18690 0 0 {name=p997 lab=_2313_/X }
C {devices/lab_pin.sym} 1770 -18750 0 1 {name=p998 lab=_2402_/D }
C {sky130_stdcells/a2bb2o_4.sym} 1690 -18750 0 0 {name=X_2314_ }
C {devices/lab_pin.sym} 1630 -18620 0 0 {name=p999 lab=_2174_/Y }
C {devices/lab_pin.sym} 1630 -18580 0 0 {name=p1000 lab=_1708_/X }
C {devices/lab_pin.sym} 1630 -18540 0 0 {name=p1001 lab=_2176_/C }
C {devices/lab_pin.sym} 1750 -18580 0 1 {name=p1002 lab=_2176_/Y }
C {sky130_stdcells/nand3_4.sym} 1690 -18580 0 0 {name=X_2176_ }
C {sky130_stdcells/decap_3.sym} 1690 -18410 0 0 {name=XPHY_121 }
C {sky130_stdcells/decap_3.sym} 1690 -18230 0 0 {name=XPHY_110 }
C {devices/lab_pin.sym} 1650 -18080 0 0 {name=p1003 lab=_2030_/A }
C {devices/lab_pin.sym} 1730 -18080 0 1 {name=p1004 lab=_2030_/X }
C {sky130_stdcells/buf_2.sym} 1690 -18080 0 0 {name=X_2030_ }
C {sky130_stdcells/decap_3.sym} 1690 -17930 0 0 {name=XPHY_1 }
C {devices/lab_pin.sym} 1610 -17800 0 0 {name=p1005 lab=_2578_/Q }
C {devices/lab_pin.sym} 1610 -17760 0 0 {name=p1006 lab=_1810_/X }
C {devices/lab_pin.sym} 1610 -17720 0 0 {name=p1007 lab=_1813_/X }
C {devices/lab_pin.sym} 1770 -17760 0 1 {name=p1008 lab=_1814_/X }
C {sky130_stdcells/o21a_4.sym} 1690 -17760 0 0 {name=X_1814_ }
C {devices/lab_pin.sym} 1610 -17650 0 0 {name=p1009 lab=_2300_/C }
C {devices/lab_pin.sym} 1610 -17610 0 0 {name=p1010 lab=_1703_/X }
C {devices/lab_pin.sym} 1610 -17570 0 0 {name=p1011 lab=_2179_/B }
C {devices/lab_pin.sym} 1610 -17530 0 0 {name=p1012 lab=_1744_/Y }
C {devices/lab_pin.sym} 1770 -17590 0 1 {name=p1013 lab=_1745_/X }
C {sky130_stdcells/a211o_4.sym} 1690 -17590 0 0 {name=X_1745_ }
C {devices/lab_pin.sym} 1630 -17450 0 0 {name=p1014 lab=_1726_/A }
C {devices/lab_pin.sym} 1630 -17410 0 0 {name=p1015 lab=_1676_/B }
C {devices/lab_pin.sym} 1750 -17430 0 1 {name=p1016 lab=_1676_/Y }
C {sky130_stdcells/nand2_4.sym} 1690 -17430 0 0 {name=X_1676_ }
C {devices/lab_pin.sym} 1610 -17320 0 0 {name=p1017 lab=_2217_/Y }
C {devices/lab_pin.sym} 1610 -17280 0 0 {name=p1018 lab=_2226_/Y }
C {devices/lab_pin.sym} 1610 -17240 0 0 {name=p1019 lab=_2227_/Y }
C {devices/lab_pin.sym} 1770 -17280 0 1 {name=p1020 lab=_2228_/Y }
C {sky130_stdcells/o21ai_4.sym} 1690 -17280 0 0 {name=X_2228_ }
C {devices/lab_pin.sym} 1610 -17170 0 0 {name=p1021 lab=_1960_/A }
C {devices/lab_pin.sym} 1610 -17130 0 0 {name=p1022 lab=_1635_/X }
C {devices/lab_pin.sym} 1610 -17090 0 0 {name=p1023 lab=_1632_/Y }
C {devices/lab_pin.sym} 1610 -17050 0 0 {name=p1024 lab=_2158_/Y }
C {devices/lab_pin.sym} 1770 -17110 0 1 {name=p1025 lab=_2159_/X }
C {sky130_stdcells/a211o_4.sym} 1690 -17110 0 0 {name=X_2159_ }
C {devices/lab_pin.sym} 1650 -16960 0 0 {name=p1026 lab=clkbuf_2_0_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 1730 -16960 0 1 {name=p1027 lab=clkbuf_4_1_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 1690 -16960 0 0 {name=Xclkbuf_3_0_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 1610 -16860 0 0 {name=p1028 lab=_1379_/X }
C {devices/lab_pin.sym} 1610 -16820 0 0 {name=p1029 lab=_1385_/D }
C {devices/lab_pin.sym} 1610 -16780 0 0 {name=p1030 lab=_2063_/A }
C {devices/lab_pin.sym} 1770 -16820 0 1 {name=p1031 lab=_1392_/Y }
C {sky130_stdcells/a21oi_4.sym} 1690 -16820 0 0 {name=X_1392_ }
C {devices/lab_pin.sym} 1630 -16700 0 0 {name=p1032 lab=_1442_/X }
C {devices/lab_pin.sym} 1630 -16660 0 0 {name=p1033 lab=_1545_/A }
C {devices/lab_pin.sym} 1630 -16620 0 0 {name=p1034 lab=_1529_/Y }
C {devices/lab_pin.sym} 1750 -16660 0 1 {name=p1035 lab=_1530_/Y }
C {sky130_stdcells/nand3_4.sym} 1690 -16660 0 0 {name=X_1530_ }
C {devices/lab_pin.sym} 1650 -16520 0 0 {name=p1036 lab=_1460_/X }
C {devices/lab_pin.sym} 1730 -16520 0 1 {name=p1037 lab=_2333_/B }
C {sky130_stdcells/buf_2.sym} 1690 -16520 0 0 {name=X_1461_ }
C {devices/lab_pin.sym} 1630 -16430 0 0 {name=p1038 lab=_2002_/X }
C {devices/lab_pin.sym} 1630 -16390 0 0 {name=p1039 lab=_2003_/Y }
C {devices/lab_pin.sym} 1630 -16350 0 0 {name=p1040 lab=_2013_/C }
C {devices/lab_pin.sym} 1630 -16310 0 0 {name=p1041 lab=_2013_/D }
C {devices/lab_pin.sym} 1750 -16370 0 1 {name=p1042 lab=_2019_/B }
C {sky130_stdcells/nor4_4.sym} 1690 -16370 0 0 {name=X_2013_ }
C {devices/lab_pin.sym} 1630 -16240 0 0 {name=p1043 lab=_1697_/A }
C {devices/lab_pin.sym} 1630 -16200 0 0 {name=p1044 lab=_1689_/A }
C {devices/lab_pin.sym} 1630 -16160 0 0 {name=p1045 lab=_1728_/C }
C {devices/lab_pin.sym} 1750 -16200 0 1 {name=p1046 lab=_1728_/Y }
C {sky130_stdcells/nor3_4.sym} 1690 -16200 0 0 {name=X_1728_ }
C {devices/lab_pin.sym} 1650 -16060 0 0 {name=p1047 lab=_1659_/A }
C {devices/lab_pin.sym} 1730 -16060 0 1 {name=p1048 lab=_1660_/A }
C {sky130_stdcells/buf_2.sym} 1690 -16060 0 0 {name=X_1659_ }
C {devices/lab_pin.sym} 1600 -15940 0 0 {name=p1049 lab=_2562_/CLK }
C {devices/lab_pin.sym} 1600 -15920 0 0 {name=p1050 lab=_2562_/D }
C {devices/lab_pin.sym} 1780 -15940 0 1 {name=p1051 lab=_2562_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -15930 0 0 {name=X_2562_ }
C {devices/lab_pin.sym} 1600 -15800 0 0 {name=p1052 lab=_2626_/CLK }
C {devices/lab_pin.sym} 1600 -15780 0 0 {name=p1053 lab=_1341_/X }
C {devices/lab_pin.sym} 1780 -15800 0 1 {name=p1054 lab=_1242_/B }
C {sky130_stdcells/dfxtp_4.sym} 1690 -15790 0 0 {name=X_2631_ }
C {devices/lab_pin.sym} 1600 -15660 0 0 {name=p1055 lab=_2470_/CLK }
C {devices/lab_pin.sym} 1600 -15640 0 0 {name=p1056 lab=_2493_/D }
C {devices/lab_pin.sym} 1780 -15660 0 1 {name=p1057 lab=CLK_LED }
C {sky130_stdcells/dfxtp_4.sym} 1690 -15650 0 0 {name=X_2493_ }
C {devices/lab_pin.sym} 1610 -15540 0 0 {name=p1058 lab=_1236_/A }
C {devices/lab_pin.sym} 1610 -15500 0 0 {name=p1059 lab=_1373_/X }
C {devices/lab_pin.sym} 1610 -15460 0 0 {name=p1060 lab=_1374_/X }
C {devices/lab_pin.sym} 1770 -15500 0 1 {name=p1061 lab=_1375_/X }
C {sky130_stdcells/o21a_4.sym} 1690 -15500 0 0 {name=X_1375_ }
C {devices/lab_pin.sym} 1650 -15360 0 0 {name=p1062 lab=_2385_/Q }
C {devices/lab_pin.sym} 1730 -15360 0 1 {name=p1063 lab=_1444_/Y }
C {sky130_stdcells/inv_2.sym} 1690 -15360 0 0 {name=X_1444_ }
C {devices/lab_pin.sym} 1610 -15260 0 0 {name=p1064 lab=_1511_/Y }
C {devices/lab_pin.sym} 1610 -15220 0 0 {name=p1065 lab=_1512_/Y }
C {devices/lab_pin.sym} 1610 -15180 0 0 {name=p1066 lab=_1508_/X }
C {devices/lab_pin.sym} 1770 -15220 0 1 {name=p1067 lab=_1513_/X }
C {sky130_stdcells/a21o_4.sym} 1690 -15220 0 0 {name=X_1513_ }
C {devices/lab_pin.sym} 1630 -15110 0 0 {name=p1068 lab=_1993_/A }
C {devices/lab_pin.sym} 1630 -15070 0 0 {name=p1069 lab=_1993_/B }
C {devices/lab_pin.sym} 1630 -15030 0 0 {name=p1070 lab=_1993_/C }
C {devices/lab_pin.sym} 1630 -14990 0 0 {name=p1071 lab=_1993_/D }
C {devices/lab_pin.sym} 1750 -15050 0 1 {name=p1072 lab=_1994_/D }
C {sky130_stdcells/nand4_4.sym} 1690 -15050 0 0 {name=X_1993_ }
C {devices/lab_pin.sym} 1600 -14900 0 0 {name=p1073 lab=_2550_/CLK }
C {devices/lab_pin.sym} 1600 -14880 0 0 {name=p1074 lab=_2545_/D }
C {devices/lab_pin.sym} 1780 -14900 0 1 {name=p1075 lab=_2351_/A }
C {sky130_stdcells/dfxtp_4.sym} 1690 -14890 0 0 {name=X_2545_ }
C {devices/lab_pin.sym} 1600 -14760 0 0 {name=p1076 lab=_2618_/CLK }
C {devices/lab_pin.sym} 1600 -14740 0 0 {name=p1077 lab=_2614_/D }
C {devices/lab_pin.sym} 1780 -14760 0 1 {name=p1078 lab=_1409_/B }
C {sky130_stdcells/dfxtp_4.sym} 1690 -14750 0 0 {name=X_2614_ }
C {devices/lab_pin.sym} 1600 -14620 0 0 {name=p1079 lab=_2483_/CLK }
C {devices/lab_pin.sym} 1600 -14600 0 0 {name=p1080 lab=_2075_/Y }
C {devices/lab_pin.sym} 1780 -14620 0 1 {name=p1081 lab=_1990_/B }
C {sky130_stdcells/dfxtp_4.sym} 1690 -14610 0 0 {name=X_2476_ }
C {devices/lab_pin.sym} 1630 -14500 0 0 {name=p1082 lab=_1358_/A }
C {devices/lab_pin.sym} 1630 -14460 0 0 {name=p1083 lab=_2006_/B }
C {devices/lab_pin.sym} 1630 -14420 0 0 {name=p1084 lab=_1358_/C }
C {devices/lab_pin.sym} 1750 -14460 0 1 {name=p1085 lab=_1358_/Y }
C {sky130_stdcells/nand3_4.sym} 1690 -14460 0 0 {name=X_1358_ }
C {devices/lab_pin.sym} 1650 -14320 0 0 {name=p1086 lab=_1427_/A }
C {devices/lab_pin.sym} 1730 -14320 0 1 {name=p1087 lab=_1428_/D }
C {sky130_stdcells/buf_2.sym} 1690 -14320 0 0 {name=X_1427_ }
C {devices/lab_pin.sym} 1630 -14220 0 0 {name=p1088 lab=_1289_/A }
C {devices/lab_pin.sym} 1630 -14180 0 0 {name=p1089 lab=_1971_/A }
C {devices/lab_pin.sym} 1630 -14140 0 0 {name=p1090 lab=_1289_/C }
C {devices/lab_pin.sym} 1750 -14180 0 1 {name=p1091 lab=_1290_/A }
C {sky130_stdcells/nand3_4.sym} 1690 -14180 0 0 {name=X_1289_ }
C {devices/lab_pin.sym} 1630 -14050 0 0 {name=p1092 lab=_1762_/A }
C {devices/lab_pin.sym} 1630 -14010 0 0 {name=p1093 lab=_2437_/Q }
C {devices/lab_pin.sym} 1750 -14030 0 1 {name=p1094 lab=_2192_/Y }
C {sky130_stdcells/nand2_4.sym} 1690 -14030 0 0 {name=X_2192_ }
C {devices/lab_pin.sym} 1650 -13900 0 0 {name=p1095 lab=_1188_/A }
C {devices/lab_pin.sym} 1730 -13900 0 1 {name=p1096 lab=_2322_/A }
C {sky130_stdcells/buf_2.sym} 1690 -13900 0 0 {name=X_1212_ }
C {devices/lab_pin.sym} 1610 -13810 0 0 {name=p1097 lab=_2463_/Q }
C {devices/lab_pin.sym} 1610 -13770 0 0 {name=p1098 lab=_2385_/Q }
C {devices/lab_pin.sym} 1610 -13730 0 0 {name=p1099 lab=_2322_/A }
C {devices/lab_pin.sym} 1610 -13690 0 0 {name=p1100 lab=_2333_/B }
C {devices/lab_pin.sym} 1770 -13750 0 1 {name=p1101 lab=_2330_/Y }
C {sky130_stdcells/a22oi_4.sym} 1690 -13750 0 0 {name=X_2330_ }
C {devices/lab_pin.sym} 1610 -13640 0 0 {name=p1102 lab=_2243_/Y }
C {devices/lab_pin.sym} 1610 -13600 0 0 {name=p1103 lab=_2260_/Y }
C {devices/lab_pin.sym} 1610 -13560 0 0 {name=p1104 lab=_2258_/X }
C {devices/lab_pin.sym} 1610 -13520 0 0 {name=p1105 lab=_1914_/B }
C {devices/lab_pin.sym} 1610 -13480 0 0 {name=p1106 lab=_2248_/X }
C {devices/lab_pin.sym} 1770 -13560 0 1 {name=p1107 lab=_2427_/D }
C {sky130_stdcells/o32ai_4.sym} 1690 -13560 0 0 {name=X_2261_ }
C {devices/lab_pin.sym} 1630 -13410 0 0 {name=p1108 lab=_1976_/A }
C {devices/lab_pin.sym} 1630 -13370 0 0 {name=p1109 lab=_1976_/B }
C {devices/lab_pin.sym} 1750 -13390 0 1 {name=p1110 lab=_1980_/A }
C {sky130_stdcells/nor2_4.sym} 1690 -13390 0 0 {name=X_1976_ }
C {devices/lab_pin.sym} 1600 -13260 0 0 {name=p1111 lab=_2528_/CLK }
C {devices/lab_pin.sym} 1600 -13240 0 0 {name=p1112 lab=_2528_/D }
C {devices/lab_pin.sym} 1780 -13260 0 1 {name=p1113 lab=_1933_/B }
C {sky130_stdcells/dfxtp_4.sym} 1690 -13250 0 0 {name=X_2528_ }
C {devices/lab_pin.sym} 1600 -13120 0 0 {name=p1114 lab=_2570_/CLK }
C {devices/lab_pin.sym} 1600 -13100 0 0 {name=p1115 lab=_2105_/X }
C {devices/lab_pin.sym} 1780 -13120 0 1 {name=p1116 lab=_2103_/A }
C {sky130_stdcells/dfxtp_4.sym} 1690 -13110 0 0 {name=X_2459_ }
C {devices/lab_pin.sym} 1650 -12980 0 0 {name=p1117 lab=clkbuf_4_1_0_m1_clk_local/A }
C {devices/lab_pin.sym} 1730 -12980 0 1 {name=p1118 lab=_2519_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 1690 -12980 0 0 {name=Xclkbuf_4_0_0_m1_clk_local }
C {devices/lab_pin.sym} 1630 -12880 0 0 {name=p1119 lab=_1179_/X }
C {devices/lab_pin.sym} 1630 -12840 0 0 {name=p1120 lab=_1735_/C }
C {devices/lab_pin.sym} 1630 -12800 0 0 {name=p1121 lab=_1735_/D }
C {devices/lab_pin.sym} 1750 -12840 0 1 {name=p1122 lab=_1830_/Y }
C {sky130_stdcells/nand3_4.sym} 1690 -12840 0 0 {name=X_1830_ }
C {devices/lab_pin.sym} 1650 -12700 0 0 {name=p1123 lab=_1739_/A }
C {devices/lab_pin.sym} 1730 -12700 0 1 {name=p1124 lab=_1762_/A }
C {sky130_stdcells/buf_2.sym} 1690 -12700 0 0 {name=X_1761_ }
C {devices/lab_pin.sym} 1610 -12610 0 0 {name=p1125 lab=_1691_/Y }
C {devices/lab_pin.sym} 1610 -12570 0 0 {name=p1126 lab=_1488_/X }
C {devices/lab_pin.sym} 1610 -12530 0 0 {name=p1127 lab=_1780_/B }
C {devices/lab_pin.sym} 1610 -12490 0 0 {name=p1128 lab=_1731_/B }
C {devices/lab_pin.sym} 1770 -12550 0 1 {name=p1129 lab=_1692_/X }
C {sky130_stdcells/a2bb2o_4.sym} 1690 -12550 0 0 {name=X_1692_ }
C {devices/lab_pin.sym} 1650 -12400 0 0 {name=p1130 lab=_2312_/X }
C {devices/lab_pin.sym} 1730 -12400 0 1 {name=p1131 lab=_2313_/X }
C {sky130_stdcells/buf_2.sym} 1690 -12400 0 0 {name=X_2313_ }
C {devices/lab_pin.sym} 1650 -12280 0 0 {name=p1132 lab=_2243_/Y }
C {devices/lab_pin.sym} 1730 -12280 0 1 {name=p1133 lab=_2244_/X }
C {sky130_stdcells/buf_2.sym} 1690 -12280 0 0 {name=X_2244_ }
C {devices/lab_pin.sym} 1630 -12170 0 0 {name=p1134 lab=_1232_/A }
C {devices/lab_pin.sym} 1630 -12130 0 0 {name=p1135 lab=_2175_/B }
C {devices/lab_pin.sym} 1750 -12150 0 1 {name=p1136 lab=_2176_/C }
C {sky130_stdcells/nand2_4.sym} 1690 -12150 0 0 {name=X_2175_ }
C {devices/lab_pin.sym} 1630 -12030 0 0 {name=p1137 lab=_1969_/A }
C {devices/lab_pin.sym} 1630 -11990 0 0 {name=p1138 lab=_2515_/Q }
C {devices/lab_pin.sym} 1750 -12010 0 1 {name=p1139 lab=_1959_/X }
C {sky130_stdcells/and2_4.sym} 1690 -12010 0 0 {name=X_1959_ }
C {sky130_stdcells/decap_3.sym} 1690 -11850 0 0 {name=XPHY_100 }
C {sky130_stdcells/decap_3.sym} 1690 -11670 0 0 {name=XPHY_122 }
C {sky130_stdcells/decap_3.sym} 1690 -11490 0 0 {name=XPHY_111 }
C {devices/lab_pin.sym} 1650 -11340 0 0 {name=p1140 lab=clkbuf_3_7_0_m1_clk_local/A }
C {devices/lab_pin.sym} 1730 -11340 0 1 {name=p1141 lab=clkbuf_3_6_0_m1_clk_local/X }
C {sky130_stdcells/clkbuf_1.sym} 1690 -11340 0 0 {name=Xclkbuf_3_6_0_m1_clk_local }
C {sky130_stdcells/decap_3.sym} 1690 -11190 0 0 {name=XPHY_2 }
C {devices/lab_pin.sym} 1650 -11040 0 0 {name=p1142 lab=_1838_/A }
C {devices/lab_pin.sym} 1730 -11040 0 1 {name=p1143 lab=_1813_/X }
C {sky130_stdcells/buf_2.sym} 1690 -11040 0 0 {name=X_1813_ }
C {devices/lab_pin.sym} 1630 -10930 0 0 {name=p1144 lab=_1630_/X }
C {devices/lab_pin.sym} 1630 -10890 0 0 {name=p1145 lab=_1744_/B }
C {devices/lab_pin.sym} 1750 -10910 0 1 {name=p1146 lab=_1744_/Y }
C {sky130_stdcells/nor2_4.sym} 1690 -10910 0 0 {name=X_1744_ }
C {devices/lab_pin.sym} 1650 -10780 0 0 {name=p1147 lab=_1739_/A }
C {devices/lab_pin.sym} 1730 -10780 0 1 {name=p1148 lab=_1726_/A }
C {sky130_stdcells/buf_2.sym} 1690 -10780 0 0 {name=X_1675_ }
C {devices/lab_pin.sym} 1610 -10690 0 0 {name=p1149 lab=_1300_/B }
C {devices/lab_pin.sym} 1610 -10650 0 0 {name=p1150 lab=_1640_/X }
C {devices/lab_pin.sym} 1610 -10610 0 0 {name=p1151 lab=_1651_/X }
C {devices/lab_pin.sym} 1610 -10570 0 0 {name=p1152 lab=_1856_/A }
C {devices/lab_pin.sym} 1770 -10630 0 1 {name=p1153 lab=_2227_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 1690 -10630 0 0 {name=X_2227_ }
C {devices/lab_pin.sym} 1650 -10480 0 0 {name=p1154 lab=_2089_/A }
C {devices/lab_pin.sym} 1730 -10480 0 1 {name=p1155 lab=_2089_/Y }
C {sky130_stdcells/inv_2.sym} 1690 -10480 0 0 {name=X_2089_ }
C {devices/lab_pin.sym} 1630 -10370 0 0 {name=p1156 lab=_1703_/X }
C {devices/lab_pin.sym} 1630 -10330 0 0 {name=p1157 lab=_2158_/B }
C {devices/lab_pin.sym} 1750 -10350 0 1 {name=p1158 lab=_2158_/Y }
C {sky130_stdcells/nor2_4.sym} 1690 -10350 0 0 {name=X_2158_ }
C {devices/lab_pin.sym} 1650 -10220 0 0 {name=p1159 lab=_1274_/X }
C {devices/lab_pin.sym} 1730 -10220 0 1 {name=p1160 lab=_2063_/A }
C {sky130_stdcells/buf_2.sym} 1690 -10220 0 0 {name=X_1391_ }
C {devices/lab_pin.sym} 1650 -10100 0 0 {name=p1161 lab=_2390_/Q }
C {devices/lab_pin.sym} 1730 -10100 0 1 {name=p1162 lab=_1460_/X }
C {sky130_stdcells/buf_2.sym} 1690 -10100 0 0 {name=X_1460_ }
C {devices/lab_pin.sym} 1650 -9980 0 0 {name=p1163 lab=_2008_/A }
C {devices/lab_pin.sym} 1730 -9980 0 1 {name=p1164 lab=_2013_/D }
C {sky130_stdcells/buf_2.sym} 1690 -9980 0 0 {name=X_2012_ }
C {devices/lab_pin.sym} 1630 -9870 0 0 {name=p1165 lab=_1725_/X }
C {devices/lab_pin.sym} 1630 -9830 0 0 {name=p1166 lab=_1726_/Y }
C {devices/lab_pin.sym} 1750 -9850 0 1 {name=p1167 lab=_2593_/D }
C {sky130_stdcells/nand2_4.sym} 1690 -9850 0 0 {name=X_1727_ }
C {devices/lab_pin.sym} 1610 -9740 0 0 {name=p1168 lab=_1612_/X }
C {devices/lab_pin.sym} 1610 -9700 0 0 {name=p1169 lab=_1653_/Y }
C {devices/lab_pin.sym} 1610 -9660 0 0 {name=p1170 lab=_1657_/Y }
C {devices/lab_pin.sym} 1770 -9700 0 1 {name=p1171 lab=_1658_/Y }
C {sky130_stdcells/o21ai_4.sym} 1690 -9700 0 0 {name=X_1658_ }
C {devices/lab_pin.sym} 1650 -9560 0 0 {name=p1172 lab=_1426_/A }
C {devices/lab_pin.sym} 1730 -9560 0 1 {name=p1173 lab=_1590_/B }
C {sky130_stdcells/inv_2.sym} 1690 -9560 0 0 {name=X_1589_ }
C {devices/lab_pin.sym} 1600 -9440 0 0 {name=p1174 lab=_2372_/CLK }
C {devices/lab_pin.sym} 1600 -9420 0 0 {name=p1175 lab=_2492_/D }
C {devices/lab_pin.sym} 1780 -9440 0 1 {name=p1176 lab=_2492_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -9430 0 0 {name=X_2492_ }
C {devices/lab_pin.sym} 1600 -9300 0 0 {name=p1177 lab=_2550_/CLK }
C {devices/lab_pin.sym} 1600 -9280 0 0 {name=p1178 lab=_2561_/D }
C {devices/lab_pin.sym} 1780 -9300 0 1 {name=p1179 lab=_2561_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -9290 0 0 {name=X_2561_ }
C {devices/lab_pin.sym} 1600 -9160 0 0 {name=p1180 lab=_2477_/CLK }
C {devices/lab_pin.sym} 1600 -9140 0 0 {name=p1181 lab=_1343_/X }
C {devices/lab_pin.sym} 1780 -9160 0 1 {name=p1182 lab=_1242_/C }
C {sky130_stdcells/dfxtp_4.sym} 1690 -9150 0 0 {name=X_2630_ }
C {devices/lab_pin.sym} 1650 -9020 0 0 {name=p1183 lab=_1486_/A }
C {devices/lab_pin.sym} 1730 -9020 0 1 {name=p1184 lab=_1512_/Y }
C {sky130_stdcells/inv_2.sym} 1690 -9020 0 0 {name=X_1512_ }
C {devices/lab_pin.sym} 1650 -8900 0 0 {name=p1185 lab=_1374_/A }
C {devices/lab_pin.sym} 1730 -8900 0 1 {name=p1186 lab=_1374_/X }
C {sky130_stdcells/buf_2.sym} 1690 -8900 0 0 {name=X_1374_ }
C {devices/lab_pin.sym} 1650 -8780 0 0 {name=p1187 lab=_1443_/A }
C {devices/lab_pin.sym} 1730 -8780 0 1 {name=p1188 lab=_1445_/A }
C {sky130_stdcells/inv_2.sym} 1690 -8780 0 0 {name=X_1443_ }
C {devices/lab_pin.sym} 1630 -8690 0 0 {name=p1189 lab=_1992_/A }
C {devices/lab_pin.sym} 1630 -8650 0 0 {name=p1190 lab=_1992_/B }
C {devices/lab_pin.sym} 1630 -8610 0 0 {name=p1191 lab=_2060_/A }
C {devices/lab_pin.sym} 1630 -8570 0 0 {name=p1192 lab=_1992_/D }
C {devices/lab_pin.sym} 1750 -8630 0 1 {name=p1193 lab=_1993_/B }
C {sky130_stdcells/nor4_4.sym} 1690 -8630 0 0 {name=X_1992_ }
C {devices/lab_pin.sym} 1600 -8480 0 0 {name=p1194 lab=_2550_/CLK }
C {devices/lab_pin.sym} 1600 -8460 0 0 {name=p1195 lab=_1899_/X }
C {devices/lab_pin.sym} 1780 -8480 0 1 {name=p1196 lab=_2544_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -8470 0 0 {name=X_2544_ }
C {devices/lab_pin.sym} 1600 -8340 0 0 {name=p1197 lab=_2477_/CLK }
C {devices/lab_pin.sym} 1600 -8320 0 0 {name=p1198 lab=_2475_/D }
C {devices/lab_pin.sym} 1780 -8340 0 1 {name=p1199 lab=_2071_/A }
C {sky130_stdcells/dfxtp_4.sym} 1690 -8330 0 0 {name=X_2475_ }
C {devices/lab_pin.sym} 1600 -8200 0 0 {name=p1200 lab=_2370_/CLK }
C {devices/lab_pin.sym} 1600 -8180 0 0 {name=p1201 lab=_1419_/X }
C {devices/lab_pin.sym} 1780 -8200 0 1 {name=p1202 lab=_1232_/D }
C {sky130_stdcells/dfxtp_4.sym} 1690 -8190 0 0 {name=X_2613_ }
C {devices/lab_pin.sym} 1610 -8080 0 0 {name=p1203 lab=_1228_/Y }
C {devices/lab_pin.sym} 1610 -8040 0 0 {name=p1204 lab=_1350_/X }
C {devices/lab_pin.sym} 1610 -8000 0 0 {name=p1205 lab=_1349_/Y }
C {devices/lab_pin.sym} 1770 -8040 0 1 {name=p1206 lab=_1358_/C }
C {sky130_stdcells/o21ai_4.sym} 1690 -8040 0 0 {name=X_1357_ }
C {devices/lab_pin.sym} 1650 -7900 0 0 {name=p1207 lab=_1426_/A }
C {devices/lab_pin.sym} 1730 -7900 0 1 {name=p1208 lab=_1428_/C }
C {sky130_stdcells/buf_2.sym} 1690 -7900 0 0 {name=X_1426_ }
C {devices/lab_pin.sym} 1610 -7800 0 0 {name=p1209 lab=_1257_/X }
C {devices/lab_pin.sym} 1610 -7760 0 0 {name=p1210 lab=_1260_/Y }
C {devices/lab_pin.sym} 1610 -7720 0 0 {name=p1211 lab=_1225_/X }
C {devices/lab_pin.sym} 1770 -7760 0 1 {name=p1212 lab=_1289_/C }
C {sky130_stdcells/o21ai_4.sym} 1690 -7760 0 0 {name=X_1288_ }
C {devices/lab_pin.sym} 1610 -7650 0 0 {name=p1213 lab=_2351_/A }
C {devices/lab_pin.sym} 1610 -7610 0 0 {name=p1214 lab=_1739_/B }
C {devices/lab_pin.sym} 1610 -7570 0 0 {name=p1215 lab=_2190_/Y }
C {devices/lab_pin.sym} 1610 -7530 0 0 {name=p1216 lab=_2168_/Y }
C {devices/lab_pin.sym} 1770 -7590 0 1 {name=p1217 lab=_2191_/Y }
C {sky130_stdcells/a22oi_4.sym} 1690 -7590 0 0 {name=X_2191_ }
C {devices/lab_pin.sym} 1610 -7460 0 0 {name=p1218 lab=_2645_/Q }
C {devices/lab_pin.sym} 1610 -7420 0 0 {name=p1219 lab=_1194_/B }
C {devices/lab_pin.sym} 1610 -7380 0 0 {name=p1220 lab=_1210_/X }
C {devices/lab_pin.sym} 1770 -7420 0 1 {name=p1221 lab=_1211_/Y }
C {sky130_stdcells/o21ai_4.sym} 1690 -7420 0 0 {name=X_1211_ }
C {devices/lab_pin.sym} 1630 -7300 0 0 {name=p1222 lab=_1840_/B }
C {devices/lab_pin.sym} 1630 -7260 0 0 {name=p1223 lab=_1698_/A }
C {devices/lab_pin.sym} 1630 -7220 0 0 {name=p1224 lab=_1520_/X }
C {devices/lab_pin.sym} 1750 -7260 0 1 {name=p1225 lab=_2260_/Y }
C {sky130_stdcells/nand3_4.sym} 1690 -7260 0 0 {name=X_2260_ }
C {devices/lab_pin.sym} 1630 -7140 0 0 {name=p1226 lab=_1976_/A }
C {devices/lab_pin.sym} 1630 -7100 0 0 {name=p1227 lab=_1976_/B }
C {devices/lab_pin.sym} 1630 -7060 0 0 {name=p1228 lab=_1975_/C }
C {devices/lab_pin.sym} 1750 -7100 0 1 {name=p1229 lab=_2498_/D }
C {sky130_stdcells/nor3_4.sym} 1690 -7100 0 0 {name=X_1975_ }
C {devices/lab_pin.sym} 1630 -6980 0 0 {name=p1230 lab=_1409_/A }
C {devices/lab_pin.sym} 1630 -6940 0 0 {name=p1231 lab=_1409_/B }
C {devices/lab_pin.sym} 1630 -6900 0 0 {name=p1232 lab=_1409_/C }
C {devices/lab_pin.sym} 1750 -6940 0 1 {name=p1233 lab=_1409_/Y }
C {sky130_stdcells/nand3_4.sym} 1690 -6940 0 0 {name=X_1409_ }
C {devices/lab_pin.sym} 1600 -6800 0 0 {name=p1234 lab=_2570_/CLK }
C {devices/lab_pin.sym} 1600 -6780 0 0 {name=p1235 lab=_2106_/X }
C {devices/lab_pin.sym} 1780 -6800 0 1 {name=p1236 lab=_2105_/B }
C {sky130_stdcells/dfxtp_4.sym} 1690 -6790 0 0 {name=X_2458_ }
C {devices/lab_pin.sym} 1600 -6660 0 0 {name=p1237 lab=_2506_/CLK }
C {devices/lab_pin.sym} 1600 -6640 0 0 {name=p1238 lab=_2527_/D }
C {devices/lab_pin.sym} 1780 -6660 0 1 {name=p1239 lab=_2527_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -6650 0 0 {name=X_2527_ }
C {devices/lab_pin.sym} 1600 -6520 0 0 {name=p1240 lab=_2390_/CLK }
C {devices/lab_pin.sym} 1600 -6500 0 0 {name=p1241 lab=_2389_/D }
C {devices/lab_pin.sym} 1780 -6520 0 1 {name=p1242 lab=_1443_/A }
C {sky130_stdcells/dfxtp_4.sym} 1690 -6510 0 0 {name=X_2389_ }
C {devices/lab_pin.sym} 1650 -6380 0 0 {name=p1243 lab=clkbuf_4_1_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 1730 -6380 0 1 {name=p1244 lab=_2428_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 1690 -6380 0 0 {name=Xclkbuf_4_0_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 1610 -6280 0 0 {name=p1245 lab=_1758_/Y }
C {devices/lab_pin.sym} 1610 -6240 0 0 {name=p1246 lab=_1759_/Y }
C {devices/lab_pin.sym} 1610 -6200 0 0 {name=p1247 lab=_1673_/C }
C {devices/lab_pin.sym} 1770 -6240 0 1 {name=p1248 lab=_1760_/Y }
C {sky130_stdcells/a21oi_4.sym} 1690 -6240 0 0 {name=X_1760_ }
C {devices/lab_pin.sym} 1650 -6100 0 0 {name=p1249 lab=_2594_/Q }
C {devices/lab_pin.sym} 1730 -6100 0 1 {name=p1250 lab=_1691_/Y }
C {sky130_stdcells/inv_2.sym} 1690 -6100 0 0 {name=X_1691_ }
C {devices/lab_pin.sym} 1630 -6010 0 0 {name=p1251 lab=_1609_/B }
C {devices/lab_pin.sym} 1630 -5970 0 0 {name=p1252 lab=_1189_/Y }
C {devices/lab_pin.sym} 1630 -5930 0 0 {name=p1253 lab=_2245_/B }
C {devices/lab_pin.sym} 1630 -5890 0 0 {name=p1254 lab=_1694_/X }
C {devices/lab_pin.sym} 1750 -5950 0 1 {name=p1255 lab=_2312_/X }
C {sky130_stdcells/and4_4.sym} 1690 -5950 0 0 {name=X_2312_ }
C {devices/lab_pin.sym} 1630 -5810 0 0 {name=p1256 lab=_2151_/A }
C {devices/lab_pin.sym} 1630 -5770 0 0 {name=p1257 lab=_2174_/B }
C {devices/lab_pin.sym} 1750 -5790 0 1 {name=p1258 lab=_2174_/Y }
C {sky130_stdcells/nand2_4.sym} 1690 -5790 0 0 {name=X_2174_ }
C {devices/lab_pin.sym} 1650 -5660 0 0 {name=p1259 lab=_1609_/B }
C {devices/lab_pin.sym} 1730 -5660 0 1 {name=p1260 lab=_2243_/Y }
C {sky130_stdcells/inv_2.sym} 1690 -5660 0 0 {name=X_2243_ }
C {devices/lab_pin.sym} 1630 -5550 0 0 {name=p1261 lab=_1891_/A }
C {devices/lab_pin.sym} 1630 -5510 0 0 {name=p1262 lab=_2560_/Q }
C {devices/lab_pin.sym} 1750 -5530 0 1 {name=p1263 lab=_1889_/X }
C {sky130_stdcells/and2_4.sym} 1690 -5530 0 0 {name=X_1889_ }
C {devices/lab_pin.sym} 1630 -5410 0 0 {name=p1264 lab=_1969_/A }
C {devices/lab_pin.sym} 1630 -5370 0 0 {name=p1265 lab=_1958_/B }
C {devices/lab_pin.sym} 1750 -5390 0 1 {name=p1266 lab=_1958_/X }
C {sky130_stdcells/and2_4.sym} 1690 -5390 0 0 {name=X_1958_ }
C {devices/lab_pin.sym} 1650 -5260 0 0 {name=p1267 lab=clkbuf_3_5_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 1730 -5260 0 1 {name=p1268 lab=clkbuf_3_5_0_addressalyzerBlock.SPI_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 1690 -5260 0 0 {name=Xclkbuf_3_5_0_addressalyzerBlock.SPI_CLK }
C {sky130_stdcells/decap_3.sym} 1690 -5110 0 0 {name=XPHY_123 }
C {sky130_stdcells/decap_3.sym} 1690 -4930 0 0 {name=XPHY_112 }
C {sky130_stdcells/decap_3.sym} 1690 -4750 0 0 {name=XPHY_101 }
C {sky130_stdcells/decap_3.sym} 1690 -4570 0 0 {name=XPHY_3 }
C {devices/lab_pin.sym} 1630 -4440 0 0 {name=p1269 lab=_1658_/Y }
C {devices/lab_pin.sym} 1630 -4400 0 0 {name=p1270 lab=_1661_/X }
C {devices/lab_pin.sym} 1630 -4360 0 0 {name=p1271 lab=_1673_/Y }
C {devices/lab_pin.sym} 1750 -4400 0 1 {name=p1272 lab=_1674_/Y }
C {sky130_stdcells/nand3_4.sym} 1690 -4400 0 0 {name=X_1674_ }
C {devices/lab_pin.sym} 1650 -4260 0 0 {name=p1273 lab=_2415_/Q }
C {devices/lab_pin.sym} 1730 -4260 0 1 {name=p1274 lab=_1744_/B }
C {sky130_stdcells/inv_2.sym} 1690 -4260 0 0 {name=X_1743_ }
C {devices/lab_pin.sym} 1610 -4160 0 0 {name=p1275 lab=_2578_/Q }
C {devices/lab_pin.sym} 1610 -4120 0 0 {name=p1276 lab=_1809_/X }
C {devices/lab_pin.sym} 1610 -4080 0 0 {name=p1277 lab=_1811_/X }
C {devices/lab_pin.sym} 1770 -4120 0 1 {name=p1278 lab=_2579_/D }
C {sky130_stdcells/o21a_4.sym} 1690 -4120 0 0 {name=X_1812_ }
C {devices/lab_pin.sym} 1610 -4000 0 0 {name=p1279 lab=_2222_/X }
C {devices/lab_pin.sym} 1610 -3960 0 0 {name=p1280 lab=_2225_/X }
C {devices/lab_pin.sym} 1610 -3920 0 0 {name=p1281 lab=_1471_/X }
C {devices/lab_pin.sym} 1770 -3960 0 1 {name=p1282 lab=_2226_/Y }
C {sky130_stdcells/a21oi_4.sym} 1690 -3960 0 0 {name=X_2226_ }
C {devices/lab_pin.sym} 1630 -3830 0 0 {name=p1283 lab=_1971_/A }
C {devices/lab_pin.sym} 1630 -3790 0 0 {name=p1284 lab=_2088_/B }
C {devices/lab_pin.sym} 1750 -3810 0 1 {name=p1285 lab=_2088_/X }
C {sky130_stdcells/and2_4.sym} 1690 -3810 0 0 {name=X_2088_ }
C {devices/lab_pin.sym} 1610 -3700 0 0 {name=p1286 lab=_2153_/Y }
C {devices/lab_pin.sym} 1610 -3660 0 0 {name=p1287 lab=_2156_/Y }
C {devices/lab_pin.sym} 1610 -3620 0 0 {name=p1288 lab=_1628_/X }
C {devices/lab_pin.sym} 1770 -3660 0 1 {name=p1289 lab=_2157_/X }
C {sky130_stdcells/a21o_4.sym} 1690 -3660 0 0 {name=X_2157_ }
C {devices/lab_pin.sym} 1630 -3540 0 0 {name=p1290 lab=_1395_/A }
C {devices/lab_pin.sym} 1630 -3500 0 0 {name=p1291 lab=_1390_/B }
C {devices/lab_pin.sym} 1630 -3460 0 0 {name=p1292 lab=_1390_/C }
C {devices/lab_pin.sym} 1750 -3500 0 1 {name=p1293 lab=_1390_/Y }
C {sky130_stdcells/nor3_4.sym} 1690 -3500 0 0 {name=X_1390_ }
C {devices/lab_pin.sym} 1650 -3360 0 0 {name=p1294 lab=_2011_/A }
C {devices/lab_pin.sym} 1730 -3360 0 1 {name=p1295 lab=_2013_/C }
C {sky130_stdcells/inv_2.sym} 1690 -3360 0 0 {name=X_2011_ }
C {devices/lab_pin.sym} 1630 -3250 0 0 {name=p1296 lab=_1726_/A }
C {devices/lab_pin.sym} 1630 -3210 0 0 {name=p1297 lab=_2593_/Q }
C {devices/lab_pin.sym} 1750 -3230 0 1 {name=p1298 lab=_1726_/Y }
C {sky130_stdcells/nand2_4.sym} 1690 -3230 0 0 {name=X_1726_ }
C {devices/lab_pin.sym} 1610 -3120 0 0 {name=p1299 lab=_1612_/X }
C {devices/lab_pin.sym} 1610 -3080 0 0 {name=p1300 lab=_2628_/Q }
C {devices/lab_pin.sym} 1610 -3040 0 0 {name=p1301 lab=_1656_/X }
C {devices/lab_pin.sym} 1770 -3080 0 1 {name=p1302 lab=_1657_/Y }
C {sky130_stdcells/a21oi_4.sym} 1690 -3080 0 0 {name=X_1657_ }
C {devices/lab_pin.sym} 1610 -2960 0 0 {name=p1303 lab=_1577_/X }
C {devices/lab_pin.sym} 1610 -2920 0 0 {name=p1304 lab=_1460_/X }
C {devices/lab_pin.sym} 1610 -2880 0 0 {name=p1305 lab=_1514_/X }
C {devices/lab_pin.sym} 1770 -2920 0 1 {name=p1306 lab=_1588_/Y }
C {sky130_stdcells/o21ai_4.sym} 1690 -2920 0 0 {name=X_1588_ }
C {devices/lab_pin.sym} 1610 -2800 0 0 {name=p1307 lab=_1611_/A }
C {devices/lab_pin.sym} 1610 -2760 0 0 {name=p1308 lab=_1385_/A }
C {devices/lab_pin.sym} 1610 -2720 0 0 {name=p1309 lab=_1654_/Y }
C {devices/lab_pin.sym} 1770 -2760 0 1 {name=p1310 lab=_2209_/X }
C {sky130_stdcells/a21o_4.sym} 1690 -2760 0 0 {name=X_2209_ }
C {devices/lab_pin.sym} 1600 -2620 0 0 {name=p1311 lab=_2470_/CLK }
C {devices/lab_pin.sym} 1600 -2600 0 0 {name=p1312 lab=_2019_/Y }
C {devices/lab_pin.sym} 1780 -2620 0 1 {name=p1313 lab=_2011_/A }
C {sky130_stdcells/dfxtp_4.sym} 1690 -2610 0 0 {name=X_2491_ }
C {devices/lab_pin.sym} 1600 -2480 0 0 {name=p1314 lab=_2554_/CLK }
C {devices/lab_pin.sym} 1600 -2460 0 0 {name=p1315 lab=_2560_/D }
C {devices/lab_pin.sym} 1780 -2480 0 1 {name=p1316 lab=_2560_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -2470 0 0 {name=X_2560_ }
C {devices/lab_pin.sym} 1610 -2360 0 0 {name=p1317 lab=_1434_/Y }
C {devices/lab_pin.sym} 1610 -2320 0 0 {name=p1318 lab=_1422_/A }
C {devices/lab_pin.sym} 1610 -2280 0 0 {name=p1319 lab=_1528_/A }
C {devices/lab_pin.sym} 1770 -2320 0 1 {name=p1320 lab=_1442_/X }
C {sky130_stdcells/a21o_4.sym} 1690 -2320 0 0 {name=X_1442_ }
C {devices/lab_pin.sym} 1650 -2180 0 0 {name=p1321 lab=_1505_/B }
C {devices/lab_pin.sym} 1730 -2180 0 1 {name=p1322 lab=_1511_/Y }
C {sky130_stdcells/inv_2.sym} 1690 -2180 0 0 {name=X_1511_ }
C {devices/lab_pin.sym} 1630 -2090 0 0 {name=p1323 lab=_1379_/A }
C {devices/lab_pin.sym} 1630 -2050 0 0 {name=p1324 lab=_1373_/B }
C {devices/lab_pin.sym} 1630 -2010 0 0 {name=p1325 lab=_1383_/C }
C {devices/lab_pin.sym} 1630 -1970 0 0 {name=p1326 lab=_1365_/D }
C {devices/lab_pin.sym} 1750 -2030 0 1 {name=p1327 lab=_1373_/X }
C {sky130_stdcells/and4_4.sym} 1690 -2030 0 0 {name=X_1373_ }
C {devices/lab_pin.sym} 1650 -1880 0 0 {name=p1328 lab=_1709_/A }
C {devices/lab_pin.sym} 1730 -1880 0 1 {name=p1329 lab=_1710_/B }
C {sky130_stdcells/inv_2.sym} 1690 -1880 0 0 {name=X_1709_ }
C {devices/lab_pin.sym} 1630 -1790 0 0 {name=p1330 lab=_1991_/A }
C {devices/lab_pin.sym} 1630 -1750 0 0 {name=p1331 lab=_1991_/B }
C {devices/lab_pin.sym} 1630 -1710 0 0 {name=p1332 lab=_1991_/C }
C {devices/lab_pin.sym} 1630 -1670 0 0 {name=p1333 lab=_1991_/D }
C {devices/lab_pin.sym} 1750 -1730 0 1 {name=p1334 lab=_1992_/D }
C {sky130_stdcells/nand4_4.sym} 1690 -1730 0 0 {name=X_1991_ }
C {devices/lab_pin.sym} 1600 -1580 0 0 {name=p1335 lab=_2390_/CLK }
C {devices/lab_pin.sym} 1600 -1560 0 0 {name=p1336 lab=_1455_/Y }
C {devices/lab_pin.sym} 1780 -1580 0 1 {name=p1337 lab=_2335_/B }
C {sky130_stdcells/dfxtp_4.sym} 1690 -1570 0 0 {name=X_2612_ }
C {devices/lab_pin.sym} 1600 -1440 0 0 {name=p1338 lab=_2550_/CLK }
C {devices/lab_pin.sym} 1600 -1420 0 0 {name=p1339 lab=_2543_/D }
C {devices/lab_pin.sym} 1780 -1440 0 1 {name=p1340 lab=_2543_/Q }
C {sky130_stdcells/dfxtp_4.sym} 1690 -1430 0 0 {name=X_2543_ }
C {devices/lab_pin.sym} 1600 -1300 0 0 {name=p1341 lab=_2477_/CLK }
C {devices/lab_pin.sym} 1600 -1280 0 0 {name=p1342 lab=_2474_/D }
C {devices/lab_pin.sym} 1780 -1300 0 1 {name=p1343 lab=_1991_/D }
C {sky130_stdcells/dfxtp_4.sym} 1690 -1290 0 0 {name=X_2474_ }
C {devices/lab_pin.sym} 1650 -1160 0 0 {name=p1344 lab=_2600_/Q }
C {devices/lab_pin.sym} 1730 -1160 0 1 {name=p1345 lab=_1570_/A }
C {sky130_stdcells/buf_2.sym} 1690 -1160 0 0 {name=X_1425_ }
C {devices/lab_pin.sym} 1650 -1040 0 0 {name=p1346 lab=_1356_/A }
C {devices/lab_pin.sym} 1730 -1040 0 1 {name=p1347 lab=_1358_/A }
C {sky130_stdcells/inv_2.sym} 1690 -1040 0 0 {name=X_1356_ }
C {devices/lab_pin.sym} 1650 -920 0 0 {name=p1348 lab=_1277_/B }
C {devices/lab_pin.sym} 1730 -920 0 1 {name=p1349 lab=_1289_/A }
C {sky130_stdcells/inv_2.sym} 1690 -920 0 0 {name=X_1287_ }
C {devices/lab_pin.sym} 1630 -810 0 0 {name=p1350 lab=_1206_/A }
C {devices/lab_pin.sym} 1630 -770 0 0 {name=p1351 lab=_1178_/A }
C {devices/lab_pin.sym} 1750 -790 0 1 {name=p1352 lab=_1210_/X }
C {sky130_stdcells/or2_4.sym} 1690 -790 0 0 {name=X_1210_ }
C {devices/lab_pin.sym} 7190 -21900 0 0 {name=p1353 lab=_2172_/Y }
C {devices/lab_pin.sym} 7190 -21860 0 0 {name=p1354 lab=_2188_/Y }
C {devices/lab_pin.sym} 7190 -21820 0 0 {name=p1355 lab=_2189_/Y }
C {devices/lab_pin.sym} 7350 -21860 0 1 {name=p1356 lab=_2190_/Y }
C {sky130_stdcells/o21ai_4.sym} 7270 -21860 0 0 {name=X_2190_ }
C {devices/lab_pin.sym} 7190 -21740 0 0 {name=p1357 lab=_1978_/B }
C {devices/lab_pin.sym} 7190 -21700 0 0 {name=p1358 lab=_1973_/A }
C {devices/lab_pin.sym} 7190 -21660 0 0 {name=p1359 lab=_1973_/Y }
C {devices/lab_pin.sym} 7350 -21700 0 1 {name=p1360 lab=_1975_/C }
C {sky130_stdcells/a21oi_4.sym} 7270 -21700 0 0 {name=X_1974_ }
C {devices/lab_pin.sym} 7180 -21560 0 0 {name=p1361 lab=_2457_/CLK }
C {devices/lab_pin.sym} 7180 -21540 0 0 {name=p1362 lab=_2107_/X }
C {devices/lab_pin.sym} 7360 -21560 0 1 {name=p1363 lab=_2093_/B }
C {sky130_stdcells/dfxtp_4.sym} 7270 -21550 0 0 {name=X_2457_ }
C {devices/lab_pin.sym} 7210 -21440 0 0 {name=p1364 lab=_1395_/A }
C {devices/lab_pin.sym} 7210 -21400 0 0 {name=p1365 lab=_1408_/B }
C {devices/lab_pin.sym} 7210 -21360 0 0 {name=p1366 lab=_1407_/Y }
C {devices/lab_pin.sym} 7330 -21400 0 1 {name=p1367 lab=_1408_/Y }
C {sky130_stdcells/nor3_4.sym} 7270 -21400 0 0 {name=X_1408_ }
C {devices/lab_pin.sym} 7180 -21260 0 0 {name=p1368 lab=_2388_/CLK }
C {devices/lab_pin.sym} 7180 -21240 0 0 {name=p1369 lab=_2388_/D }
C {devices/lab_pin.sym} 7360 -21260 0 1 {name=p1370 lab=_1566_/A }
C {sky130_stdcells/dfxtp_4.sym} 7270 -21250 0 0 {name=X_2388_ }
C {devices/lab_pin.sym} 7180 -21120 0 0 {name=p1371 lab=_2528_/CLK }
C {devices/lab_pin.sym} 7180 -21100 0 0 {name=p1372 lab=_2526_/D }
C {devices/lab_pin.sym} 7360 -21120 0 1 {name=p1373 lab=MACRO_RD_SELECT[3] }
C {sky130_stdcells/dfxtp_4.sym} 7270 -21110 0 0 {name=X_2526_ }
C {devices/lab_pin.sym} 7230 -20980 0 0 {name=p1374 lab=_1274_/X }
C {devices/lab_pin.sym} 7310 -20980 0 1 {name=p1375 lab=_1339_/X }
C {sky130_stdcells/buf_2.sym} 7270 -20980 0 0 {name=X_1339_ }
C {devices/lab_pin.sym} 7210 -20880 0 0 {name=p1376 lab=_1697_/A }
C {devices/lab_pin.sym} 7210 -20840 0 0 {name=p1377 lab=_1728_/C }
C {devices/lab_pin.sym} 7210 -20800 0 0 {name=p1378 lab=_1689_/Y }
C {devices/lab_pin.sym} 7330 -20840 0 1 {name=p1379 lab=_1690_/Y }
C {sky130_stdcells/nor3_4.sym} 7270 -20840 0 0 {name=X_1690_ }
C {devices/lab_pin.sym} 7230 -20700 0 0 {name=p1380 lab=_2310_/X }
C {devices/lab_pin.sym} 7310 -20700 0 1 {name=p1381 lab=_2311_/X }
C {sky130_stdcells/buf_2.sym} 7270 -20700 0 0 {name=X_2311_ }
C {devices/lab_pin.sym} 7190 -20600 0 0 {name=p1382 lab=_2122_/Y }
C {devices/lab_pin.sym} 7190 -20560 0 0 {name=p1383 lab=_2239_/Y }
C {devices/lab_pin.sym} 7190 -20520 0 0 {name=p1384 lab=_2241_/Y }
C {devices/lab_pin.sym} 7350 -20560 0 1 {name=p1385 lab=_2434_/D }
C {sky130_stdcells/o21ai_4.sym} 7270 -20560 0 0 {name=X_2242_ }
C {devices/lab_pin.sym} 7190 -20440 0 0 {name=p1386 lab=_1534_/A }
C {devices/lab_pin.sym} 7190 -20400 0 0 {name=p1387 lab=_2553_/Q }
C {devices/lab_pin.sym} 7190 -20360 0 0 {name=p1388 lab=_2148_/X }
C {devices/lab_pin.sym} 7350 -20400 0 1 {name=p1389 lab=_2173_/Y }
C {sky130_stdcells/o21ai_4.sym} 7270 -20400 0 0 {name=X_2173_ }
C {devices/lab_pin.sym} 7210 -20270 0 0 {name=p1390 lab=_1969_/A }
C {devices/lab_pin.sym} 7210 -20230 0 0 {name=p1391 lab=_1957_/B }
C {devices/lab_pin.sym} 7330 -20250 0 1 {name=p1392 lab=_2509_/D }
C {sky130_stdcells/and2_4.sym} 7270 -20250 0 0 {name=X_1957_ }
C {devices/lab_pin.sym} 7210 -20130 0 0 {name=p1393 lab=_1891_/A }
C {devices/lab_pin.sym} 7210 -20090 0 0 {name=p1394 lab=_2561_/Q }
C {devices/lab_pin.sym} 7330 -20110 0 1 {name=p1395 lab=_2553_/D }
C {sky130_stdcells/and2_4.sym} 7270 -20110 0 0 {name=X_1888_ }
C {devices/lab_pin.sym} 7180 -19980 0 0 {name=p1396 lab=_2519_/CLK }
C {devices/lab_pin.sym} 7180 -19960 0 0 {name=p1397 lab=_2509_/D }
C {devices/lab_pin.sym} 7360 -19980 0 1 {name=p1398 lab=DATA_TO_HASH[2] }
C {sky130_stdcells/dfxtp_4.sym} 7270 -19970 0 0 {name=X_2509_ }
C {sky130_stdcells/decap_3.sym} 7270 -19810 0 0 {name=XPHY_124 }
C {sky130_stdcells/decap_3.sym} 7270 -19630 0 0 {name=XPHY_113 }
C {sky130_stdcells/decap_3.sym} 7270 -19450 0 0 {name=XPHY_102 }
C {devices/lab_pin.sym} 7190 -19320 0 0 {name=p1399 lab=_2579_/Q }
C {devices/lab_pin.sym} 7190 -19280 0 0 {name=p1400 lab=_1810_/X }
C {devices/lab_pin.sym} 7190 -19240 0 0 {name=p1401 lab=_1799_/X }
C {devices/lab_pin.sym} 7350 -19280 0 1 {name=p1402 lab=_1811_/X }
C {sky130_stdcells/o21a_4.sym} 7270 -19280 0 0 {name=X_1811_ }
C {sky130_stdcells/decap_3.sym} 7270 -19110 0 0 {name=XPHY_4 }
C {devices/lab_pin.sym} 7210 -18990 0 0 {name=p1403 lab=_1739_/A }
C {devices/lab_pin.sym} 7210 -18950 0 0 {name=p1404 lab=_2166_/A }
C {devices/lab_pin.sym} 7210 -18910 0 0 {name=p1405 lab=_1673_/C }
C {devices/lab_pin.sym} 7210 -18870 0 0 {name=p1406 lab=_1739_/B }
C {devices/lab_pin.sym} 7330 -18930 0 1 {name=p1407 lab=_1673_/Y }
C {sky130_stdcells/nor4_4.sym} 7270 -18930 0 0 {name=X_1673_ }
C {devices/lab_pin.sym} 7190 -18800 0 0 {name=p1408 lab=_1316_/B }
C {devices/lab_pin.sym} 7190 -18760 0 0 {name=p1409 lab=_1646_/X }
C {devices/lab_pin.sym} 7190 -18720 0 0 {name=p1410 lab=_1741_/Y }
C {devices/lab_pin.sym} 7350 -18760 0 1 {name=p1411 lab=_1742_/Y }
C {sky130_stdcells/o21ai_4.sym} 7270 -18760 0 0 {name=X_1742_ }
C {devices/lab_pin.sym} 7190 -18650 0 0 {name=p1412 lab=_1966_/A }
C {devices/lab_pin.sym} 7190 -18610 0 0 {name=p1413 lab=_1751_/A }
C {devices/lab_pin.sym} 7190 -18570 0 0 {name=p1414 lab=_1633_/X }
C {devices/lab_pin.sym} 7190 -18530 0 0 {name=p1415 lab=_2224_/Y }
C {devices/lab_pin.sym} 7350 -18590 0 1 {name=p1416 lab=_2225_/X }
C {sky130_stdcells/a211o_4.sym} 7270 -18590 0 0 {name=X_2225_ }
C {devices/lab_pin.sym} 7210 -18450 0 0 {name=p1417 lab=_1284_/X }
C {devices/lab_pin.sym} 7210 -18410 0 0 {name=p1418 lab=_2078_/X }
C {devices/lab_pin.sym} 7330 -18430 0 1 {name=p1419 lab=_2087_/Y }
C {sky130_stdcells/nor2_4.sym} 7270 -18430 0 0 {name=X_2087_ }
C {devices/lab_pin.sym} 7210 -18320 0 0 {name=p1420 lab=_2154_/Y }
C {devices/lab_pin.sym} 7210 -18280 0 0 {name=p1421 lab=_2179_/B }
C {devices/lab_pin.sym} 7210 -18240 0 0 {name=p1422 lab=_2156_/C }
C {devices/lab_pin.sym} 7330 -18280 0 1 {name=p1423 lab=_2156_/Y }
C {sky130_stdcells/nand3_4.sym} 7270 -18280 0 0 {name=X_2156_ }
C {devices/lab_pin.sym} 7210 -18160 0 0 {name=p1424 lab=_2009_/X }
C {devices/lab_pin.sym} 7210 -18120 0 0 {name=p1425 lab=_2010_/B }
C {devices/lab_pin.sym} 7210 -18080 0 0 {name=p1426 lab=_2010_/C }
C {devices/lab_pin.sym} 7330 -18120 0 1 {name=p1427 lab=_2492_/D }
C {sky130_stdcells/and3_4.sym} 7270 -18120 0 0 {name=X_2010_ }
C {devices/lab_pin.sym} 7230 -17980 0 0 {name=p1428 lab=clkbuf_3_3_0_m1_clk_local/A }
C {devices/lab_pin.sym} 7310 -17980 0 1 {name=p1429 lab=clkbuf_4_5_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 7270 -17980 0 0 {name=Xclkbuf_3_2_0_m1_clk_local }
C {devices/lab_pin.sym} 7190 -17880 0 0 {name=p1430 lab=_1722_/Y }
C {devices/lab_pin.sym} 7190 -17840 0 0 {name=p1431 lab=_1723_/Y }
C {devices/lab_pin.sym} 7190 -17800 0 0 {name=p1432 lab=_1724_/X }
C {devices/lab_pin.sym} 7350 -17840 0 1 {name=p1433 lab=_1725_/X }
C {sky130_stdcells/a21o_4.sym} 7270 -17840 0 0 {name=X_1725_ }
C {devices/lab_pin.sym} 7230 -17700 0 0 {name=p1434 lab=_1656_/A }
C {devices/lab_pin.sym} 7310 -17700 0 1 {name=p1435 lab=_1656_/X }
C {sky130_stdcells/buf_2.sym} 7270 -17700 0 0 {name=X_1656_ }
C {devices/lab_pin.sym} 7190 -17620 0 0 {name=p1436 lab=_1545_/X }
C {devices/lab_pin.sym} 7190 -17580 0 0 {name=p1437 lab=_1576_/X }
C {devices/lab_pin.sym} 7190 -17540 0 0 {name=p1438 lab=_1578_/Y }
C {devices/lab_pin.sym} 7190 -17500 0 0 {name=p1439 lab=_1582_/Y }
C {devices/lab_pin.sym} 7190 -17470 0 0 {name=p1440 lab=_1586_/X }
C {devices/lab_pin.sym} 7350 -17540 0 1 {name=p1441 lab=_1587_/Y }
C {sky130_stdcells/a41oi_4.sym} 7270 -17540 0 0 {name=X_1587_ }
C {devices/lab_pin.sym} 7190 -17400 0 0 {name=p1442 lab=_1242_/C }
C {devices/lab_pin.sym} 7190 -17360 0 0 {name=p1443 lab=_1646_/A }
C {devices/lab_pin.sym} 7190 -17320 0 0 {name=p1444 lab=_1741_/Y }
C {devices/lab_pin.sym} 7350 -17360 0 1 {name=p1445 lab=_2208_/X }
C {sky130_stdcells/o21a_4.sym} 7270 -17360 0 0 {name=X_2208_ }
C {devices/lab_pin.sym} 7190 -17260 0 0 {name=p1446 lab=_1594_/X }
C {devices/lab_pin.sym} 7190 -17220 0 0 {name=p1447 lab=_2245_/B }
C {devices/lab_pin.sym} 7190 -17180 0 0 {name=p1448 lab=_1669_/B }
C {devices/lab_pin.sym} 7190 -17140 0 0 {name=p1449 lab=_2121_/X }
C {devices/lab_pin.sym} 7190 -17110 0 0 {name=p1450 lab=_1221_/A }
C {devices/lab_pin.sym} 7350 -17180 0 1 {name=p1451 lab=_2139_/X }
C {sky130_stdcells/a41o_4.sym} 7270 -17180 0 0 {name=X_2139_ }
C {devices/lab_pin.sym} 7180 -17020 0 0 {name=p1452 lab=_2470_/CLK }
C {devices/lab_pin.sym} 7180 -17000 0 0 {name=p1453 lab=_2490_/D }
C {devices/lab_pin.sym} 7360 -17020 0 1 {name=p1454 lab=_1999_/A }
C {sky130_stdcells/dfxtp_4.sym} 7270 -17010 0 0 {name=X_2490_ }
C {devices/lab_pin.sym} 7190 -16900 0 0 {name=p1455 lab=_1507_/Y }
C {devices/lab_pin.sym} 7190 -16860 0 0 {name=p1456 lab=_1509_/X }
C {devices/lab_pin.sym} 7190 -16820 0 0 {name=p1457 lab=_1454_/X }
C {devices/lab_pin.sym} 7350 -16860 0 1 {name=p1458 lab=_2607_/D }
C {sky130_stdcells/a21oi_4.sym} 7270 -16860 0 0 {name=X_1510_ }
C {devices/lab_pin.sym} 7190 -16740 0 0 {name=p1459 lab=_1420_/Y }
C {devices/lab_pin.sym} 7190 -16700 0 0 {name=p1460 lab=_1445_/D }
C {devices/lab_pin.sym} 7190 -16660 0 0 {name=p1461 lab=_1440_/Y }
C {devices/lab_pin.sym} 7350 -16700 0 1 {name=p1462 lab=_1441_/Y }
C {sky130_stdcells/o21ai_4.sym} 7270 -16700 0 0 {name=X_1441_ }
C {devices/lab_pin.sym} 7230 -16560 0 0 {name=p1463 lab=_2623_/Q }
C {devices/lab_pin.sym} 7310 -16560 0 1 {name=p1464 lab=_1373_/B }
C {sky130_stdcells/buf_2.sym} 7270 -16560 0 0 {name=X_1372_ }
C {devices/lab_pin.sym} 7230 -16440 0 0 {name=p1465 lab=_2448_/Q }
C {devices/lab_pin.sym} 7310 -16440 0 1 {name=p1466 lab=_1708_/X }
C {sky130_stdcells/buf_2.sym} 7270 -16440 0 0 {name=X_1708_ }
C {devices/lab_pin.sym} 7190 -16340 0 0 {name=p1467 lab=_1629_/X }
C {devices/lab_pin.sym} 7190 -16300 0 0 {name=p1468 lab=_1638_/X }
C {devices/lab_pin.sym} 7190 -16260 0 0 {name=p1469 lab=_1471_/X }
C {devices/lab_pin.sym} 7350 -16300 0 1 {name=p1470 lab=_1639_/Y }
C {sky130_stdcells/a21oi_4.sym} 7270 -16300 0 0 {name=X_1639_ }
C {devices/lab_pin.sym} 7210 -16170 0 0 {name=p1471 lab=_2071_/A }
C {devices/lab_pin.sym} 7210 -16130 0 0 {name=p1472 lab=_1990_/B }
C {devices/lab_pin.sym} 7330 -16150 0 1 {name=p1473 lab=_2060_/A }
C {sky130_stdcells/nand2_4.sym} 7270 -16150 0 0 {name=X_1990_ }
C {devices/lab_pin.sym} 7180 -16020 0 0 {name=p1474 lab=_2519_/CLK }
C {devices/lab_pin.sym} 7180 -16000 0 0 {name=p1475 lab=_1903_/Y }
C {devices/lab_pin.sym} 7360 -16020 0 1 {name=p1476 lab=_2542_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7270 -16010 0 0 {name=X_2542_ }
C {devices/lab_pin.sym} 7180 -15880 0 0 {name=p1477 lab=_2581_/CLK }
C {devices/lab_pin.sym} 7180 -15860 0 0 {name=p1478 lab=_2611_/D }
C {devices/lab_pin.sym} 7360 -15880 0 1 {name=p1479 lab=_1438_/B }
C {sky130_stdcells/dfxtp_4.sym} 7270 -15870 0 0 {name=X_2611_ }
C {devices/lab_pin.sym} 7230 -15740 0 0 {name=p1480 lab=_1354_/Y }
C {devices/lab_pin.sym} 7310 -15740 0 1 {name=p1481 lab=_2628_/D }
C {sky130_stdcells/inv_2.sym} 7270 -15740 0 0 {name=X_1355_ }
C {devices/lab_pin.sym} 7180 -15620 0 0 {name=p1482 lab=_2477_/CLK }
C {devices/lab_pin.sym} 7180 -15600 0 0 {name=p1483 lab=_2473_/D }
C {devices/lab_pin.sym} 7360 -15620 0 1 {name=p1484 lab=_1991_/C }
C {sky130_stdcells/dfxtp_4.sym} 7270 -15610 0 0 {name=X_2473_ }
C {devices/lab_pin.sym} 7230 -15480 0 0 {name=p1485 lab=_1608_/B }
C {devices/lab_pin.sym} 7310 -15480 0 1 {name=p1486 lab=_1424_/Y }
C {sky130_stdcells/inv_2.sym} 7270 -15480 0 0 {name=X_1424_ }
C {devices/lab_pin.sym} 7210 -15380 0 0 {name=p1487 lab=_1284_/X }
C {devices/lab_pin.sym} 7210 -15340 0 0 {name=p1488 lab=_1261_/Y }
C {devices/lab_pin.sym} 7210 -15300 0 0 {name=p1489 lab=_1286_/C }
C {devices/lab_pin.sym} 7330 -15340 0 1 {name=p1490 lab=_2640_/D }
C {sky130_stdcells/nor3_4.sym} 7270 -15340 0 0 {name=X_1286_ }
C {devices/lab_pin.sym} 7230 -15200 0 0 {name=p1491 lab=clkbuf_4_5_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 7310 -15200 0 1 {name=p1492 lab=_2562_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 7270 -15200 0 0 {name=Xclkbuf_4_5_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 7210 -15090 0 0 {name=p1493 lab=_1973_/A }
C {devices/lab_pin.sym} 7210 -15050 0 0 {name=p1494 lab=_1980_/B }
C {devices/lab_pin.sym} 7330 -15070 0 1 {name=p1495 lab=_1973_/Y }
C {sky130_stdcells/nor2_4.sym} 7270 -15070 0 0 {name=X_1973_ }
C {devices/lab_pin.sym} 7180 -14940 0 0 {name=p1496 lab=_2528_/CLK }
C {devices/lab_pin.sym} 7180 -14920 0 0 {name=p1497 lab=_2525_/D }
C {devices/lab_pin.sym} 7360 -14940 0 1 {name=p1498 lab=MACRO_RD_SELECT[2] }
C {sky130_stdcells/dfxtp_4.sym} 7270 -14930 0 0 {name=X_2525_ }
C {devices/lab_pin.sym} 7180 -14800 0 0 {name=p1499 lab=_2457_/CLK }
C {devices/lab_pin.sym} 7180 -14780 0 0 {name=p1500 lab=_2456_/D }
C {devices/lab_pin.sym} 7360 -14800 0 1 {name=p1501 lab=_2456_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7270 -14790 0 0 {name=X_2456_ }
C {devices/lab_pin.sym} 7190 -14700 0 0 {name=p1502 lab=_1409_/A }
C {devices/lab_pin.sym} 7190 -14660 0 0 {name=p1503 lab=_2615_/Q }
C {devices/lab_pin.sym} 7190 -14620 0 0 {name=p1504 lab=_1409_/B }
C {devices/lab_pin.sym} 7190 -14580 0 0 {name=p1505 lab=_1409_/C }
C {devices/lab_pin.sym} 7190 -14550 0 0 {name=p1506 lab=_2616_/Q }
C {devices/lab_pin.sym} 7350 -14620 0 1 {name=p1507 lab=_1407_/Y }
C {sky130_stdcells/a41oi_4.sym} 7270 -14620 0 0 {name=X_1407_ }
C {devices/lab_pin.sym} 7210 -14490 0 0 {name=p1508 lab=_1324_/X }
C {devices/lab_pin.sym} 7210 -14450 0 0 {name=p1509 lab=_1335_/D }
C {devices/lab_pin.sym} 7210 -14410 0 0 {name=p1510 lab=_1329_/X }
C {devices/lab_pin.sym} 7210 -14370 0 0 {name=p1511 lab=_1321_/X }
C {devices/lab_pin.sym} 7330 -14430 0 1 {name=p1512 lab=_1338_/X }
C {sky130_stdcells/and4_4.sym} 7270 -14430 0 0 {name=X_1338_ }
C {devices/lab_pin.sym} 7180 -14280 0 0 {name=p1513 lab=_2390_/CLK }
C {devices/lab_pin.sym} 7180 -14260 0 0 {name=p1514 lab=_2387_/D }
C {devices/lab_pin.sym} 7360 -14280 0 1 {name=p1515 lab=_1683_/A }
C {sky130_stdcells/dfxtp_4.sym} 7270 -14270 0 0 {name=X_2387_ }
C {devices/lab_pin.sym} 7230 -14140 0 0 {name=p1516 lab=_1374_/A }
C {devices/lab_pin.sym} 7310 -14140 0 1 {name=p1517 lab=_1270_/A }
C {sky130_stdcells/buf_2.sym} 7270 -14140 0 0 {name=X_1269_ }
C {devices/lab_pin.sym} 7190 -14060 0 0 {name=p1518 lab=_2615_/Q }
C {devices/lab_pin.sym} 7190 -14020 0 0 {name=p1519 lab=_1571_/A }
C {devices/lab_pin.sym} 7190 -13980 0 0 {name=p1520 lab=_1568_/A }
C {devices/lab_pin.sym} 7190 -13940 0 0 {name=p1521 lab=_1660_/A }
C {devices/lab_pin.sym} 7190 -13900 0 0 {name=p1522 lab=_2146_/Y }
C {devices/lab_pin.sym} 7350 -13980 0 1 {name=p1523 lab=_2172_/Y }
C {sky130_stdcells/o41ai_4.sym} 7270 -13980 0 0 {name=X_2172_ }
C {devices/lab_pin.sym} 7210 -13840 0 0 {name=p1524 lab=_2239_/Y }
C {devices/lab_pin.sym} 7210 -13800 0 0 {name=p1525 lab=_2298_/B }
C {devices/lab_pin.sym} 7210 -13760 0 0 {name=p1526 lab=_2434_/Q }
C {devices/lab_pin.sym} 7330 -13800 0 1 {name=p1527 lab=_2241_/Y }
C {sky130_stdcells/nand3_4.sym} 7270 -13800 0 0 {name=X_2241_ }
C {devices/lab_pin.sym} 7190 -13700 0 0 {name=p1528 lab=_1594_/X }
C {devices/lab_pin.sym} 7190 -13660 0 0 {name=p1529 lab=_1600_/B }
C {devices/lab_pin.sym} 7190 -13620 0 0 {name=p1530 lab=_2245_/B }
C {devices/lab_pin.sym} 7190 -13580 0 0 {name=p1531 lab=_1696_/A }
C {devices/lab_pin.sym} 7190 -13550 0 0 {name=p1532 lab=_1736_/A }
C {devices/lab_pin.sym} 7350 -13620 0 1 {name=p1533 lab=_2310_/X }
C {sky130_stdcells/a41o_4.sym} 7270 -13620 0 0 {name=X_2310_ }
C {devices/lab_pin.sym} 7210 -13470 0 0 {name=p1534 lab=_1891_/A }
C {devices/lab_pin.sym} 7210 -13430 0 0 {name=p1535 lab=_2562_/Q }
C {devices/lab_pin.sym} 7330 -13450 0 1 {name=p1536 lab=_1887_/X }
C {sky130_stdcells/and2_4.sym} 7270 -13450 0 0 {name=X_1887_ }
C {devices/lab_pin.sym} 7230 -13320 0 0 {name=p1537 lab=_1254_/X }
C {devices/lab_pin.sym} 7310 -13320 0 1 {name=p1538 lab=_1969_/A }
C {sky130_stdcells/buf_2.sym} 7270 -13320 0 0 {name=X_1956_ }
C {devices/lab_pin.sym} 7180 -13200 0 0 {name=p1539 lab=_2496_/CLK }
C {devices/lab_pin.sym} 7180 -13180 0 0 {name=p1540 lab=_1958_/X }
C {devices/lab_pin.sym} 7360 -13200 0 1 {name=p1541 lab=DATA_TO_HASH[1] }
C {sky130_stdcells/dfxtp_4.sym} 7270 -13190 0 0 {name=X_2508_ }
C {devices/lab_pin.sym} 7180 -13060 0 0 {name=p1542 lab=_2557_/CLK }
C {devices/lab_pin.sym} 7180 -13040 0 0 {name=p1543 lab=_2439_/D }
C {devices/lab_pin.sym} 7360 -13060 0 1 {name=p1544 lab=_1966_/A }
C {sky130_stdcells/dfxtp_4.sym} 7270 -13050 0 0 {name=X_2439_ }
C {sky130_stdcells/decap_3.sym} 7270 -12890 0 0 {name=XPHY_125 }
C {sky130_stdcells/decap_3.sym} 7270 -12710 0 0 {name=XPHY_114 }
C {sky130_stdcells/decap_3.sym} 7270 -12530 0 0 {name=XPHY_103 }
C {sky130_stdcells/decap_3.sym} 7270 -12350 0 0 {name=XPHY_5 }
C {devices/lab_pin.sym} 7230 -12200 0 0 {name=p1545 lab=_1611_/A }
C {devices/lab_pin.sym} 7310 -12200 0 1 {name=p1546 lab=_1741_/Y }
C {sky130_stdcells/inv_2.sym} 7270 -12200 0 0 {name=X_1741_ }
C {devices/lab_pin.sym} 7230 -12080 0 0 {name=p1547 lab=_2461_/Q }
C {devices/lab_pin.sym} 7310 -12080 0 1 {name=p1548 lab=_1810_/X }
C {sky130_stdcells/buf_2.sym} 7270 -12080 0 0 {name=X_1810_ }
C {devices/lab_pin.sym} 7230 -11960 0 0 {name=p1549 lab=_1672_/A }
C {devices/lab_pin.sym} 7310 -11960 0 1 {name=p1550 lab=_1739_/B }
C {sky130_stdcells/buf_2.sym} 7270 -11960 0 0 {name=X_1672_ }
C {devices/lab_pin.sym} 7210 -11850 0 0 {name=p1551 lab=_1941_/A }
C {devices/lab_pin.sym} 7210 -11810 0 0 {name=p1552 lab=_1703_/A }
C {devices/lab_pin.sym} 7330 -11830 0 1 {name=p1553 lab=_2156_/C }
C {sky130_stdcells/nand2_4.sym} 7270 -11830 0 0 {name=X_2155_ }
C {devices/lab_pin.sym} 7210 -11710 0 0 {name=p1554 lab=_1703_/X }
C {devices/lab_pin.sym} 7210 -11670 0 0 {name=p1555 lab=_2223_/Y }
C {devices/lab_pin.sym} 7330 -11690 0 1 {name=p1556 lab=_2224_/Y }
C {sky130_stdcells/nor2_4.sym} 7270 -11690 0 0 {name=X_2224_ }
C {devices/lab_pin.sym} 7190 -11580 0 0 {name=p1557 lab=_2078_/X }
C {devices/lab_pin.sym} 7190 -11540 0 0 {name=p1558 lab=_1991_/B }
C {devices/lab_pin.sym} 7190 -11500 0 0 {name=p1559 lab=_2085_/Y }
C {devices/lab_pin.sym} 7350 -11540 0 1 {name=p1560 lab=_2086_/X }
C {sky130_stdcells/o21a_4.sym} 7270 -11540 0 0 {name=X_2086_ }
C {devices/lab_pin.sym} 7210 -11410 0 0 {name=p1561 lab=_1938_/A }
C {devices/lab_pin.sym} 7210 -11370 0 0 {name=p1562 lab=_1847_/Y }
C {devices/lab_pin.sym} 7330 -11390 0 1 {name=p1563 lab=_2520_/D }
C {sky130_stdcells/nor2_4.sym} 7270 -11390 0 0 {name=X_1939_ }
C {devices/lab_pin.sym} 7230 -11260 0 0 {name=p1564 lab=clkbuf_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 7310 -11260 0 1 {name=p1565 lab=clkbuf_2_3_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 7270 -11260 0 0 {name=Xclkbuf_1_1_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 7190 -11170 0 0 {name=p1566 lab=_1667_/A }
C {devices/lab_pin.sym} 7190 -11130 0 0 {name=p1567 lab=_1856_/A }
C {devices/lab_pin.sym} 7190 -11090 0 0 {name=p1568 lab=_1662_/Y }
C {devices/lab_pin.sym} 7190 -11050 0 0 {name=p1569 lab=_1672_/A }
C {devices/lab_pin.sym} 7350 -11110 0 1 {name=p1570 lab=_1724_/X }
C {sky130_stdcells/a211o_4.sym} 7270 -11110 0 0 {name=X_1724_ }
C {devices/lab_pin.sym} 7230 -10960 0 0 {name=p1571 lab=_1654_/Y }
C {devices/lab_pin.sym} 7310 -10960 0 1 {name=p1572 lab=_1656_/A }
C {sky130_stdcells/buf_2.sym} 7270 -10960 0 0 {name=X_1655_ }
C {devices/lab_pin.sym} 7190 -10860 0 0 {name=p1573 lab=_1549_/A }
C {devices/lab_pin.sym} 7190 -10820 0 0 {name=p1574 lab=_1583_/X }
C {devices/lab_pin.sym} 7190 -10780 0 0 {name=p1575 lab=_1781_/A }
C {devices/lab_pin.sym} 7350 -10820 0 1 {name=p1576 lab=_1586_/X }
C {sky130_stdcells/a21o_4.sym} 7270 -10820 0 0 {name=X_1586_ }
C {devices/lab_pin.sym} 7190 -10700 0 0 {name=p1577 lab=_2058_/X }
C {devices/lab_pin.sym} 7190 -10660 0 0 {name=p1578 lab=_2060_/Y }
C {devices/lab_pin.sym} 7190 -10620 0 0 {name=p1579 lab=_2068_/Y }
C {devices/lab_pin.sym} 7350 -10660 0 1 {name=p1580 lab=_2070_/A }
C {sky130_stdcells/o21ai_4.sym} 7270 -10660 0 0 {name=X_2069_ }
C {devices/lab_pin.sym} 7190 -10540 0 0 {name=p1581 lab=_2195_/Y }
C {devices/lab_pin.sym} 7190 -10500 0 0 {name=p1582 lab=_2205_/Y }
C {devices/lab_pin.sym} 7190 -10460 0 0 {name=p1583 lab=_2206_/Y }
C {devices/lab_pin.sym} 7350 -10500 0 1 {name=p1584 lab=_2207_/Y }
C {sky130_stdcells/o21ai_4.sym} 7270 -10500 0 0 {name=X_2207_ }
C {devices/lab_pin.sym} 7230 -10360 0 0 {name=p1585 lab=_2138_/A }
C {devices/lab_pin.sym} 7310 -10360 0 1 {name=p1586 lab=_2138_/Y }
C {sky130_stdcells/inv_2.sym} 7270 -10360 0 0 {name=X_2138_ }
C {devices/lab_pin.sym} 7190 -10260 0 0 {name=p1587 lab=_1360_/Y }
C {devices/lab_pin.sym} 7190 -10220 0 0 {name=p1588 lab=_1350_/X }
C {devices/lab_pin.sym} 7190 -10180 0 0 {name=p1589 lab=_1370_/Y }
C {devices/lab_pin.sym} 7350 -10220 0 1 {name=p1590 lab=_2625_/D }
C {sky130_stdcells/a21oi_4.sym} 7270 -10220 0 0 {name=X_1371_ }
C {devices/lab_pin.sym} 7210 -10110 0 0 {name=p1591 lab=_1423_/Y }
C {devices/lab_pin.sym} 7210 -10070 0 0 {name=p1592 lab=_1440_/B }
C {devices/lab_pin.sym} 7210 -10030 0 0 {name=p1593 lab=_1435_/Y }
C {devices/lab_pin.sym} 7210 -9990 0 0 {name=p1594 lab=_1440_/D }
C {devices/lab_pin.sym} 7330 -10050 0 1 {name=p1595 lab=_1440_/Y }
C {sky130_stdcells/nand4_4.sym} 7270 -10050 0 0 {name=X_1440_ }
C {devices/lab_pin.sym} 7190 -9930 0 0 {name=p1596 lab=_2125_/C }
C {devices/lab_pin.sym} 7190 -9890 0 0 {name=p1597 lab=_1751_/A }
C {devices/lab_pin.sym} 7190 -9850 0 0 {name=p1598 lab=_1633_/X }
C {devices/lab_pin.sym} 7190 -9810 0 0 {name=p1599 lab=_1637_/Y }
C {devices/lab_pin.sym} 7350 -9870 0 1 {name=p1600 lab=_1638_/X }
C {sky130_stdcells/a211o_4.sym} 7270 -9870 0 0 {name=X_1638_ }
C {devices/lab_pin.sym} 7190 -9750 0 0 {name=p1601 lab=_2295_/C }
C {devices/lab_pin.sym} 7190 -9710 0 0 {name=p1602 lab=_1703_/X }
C {devices/lab_pin.sym} 7190 -9670 0 0 {name=p1603 lab=_2179_/B }
C {devices/lab_pin.sym} 7190 -9630 0 0 {name=p1604 lab=_1706_/Y }
C {devices/lab_pin.sym} 7350 -9690 0 1 {name=p1605 lab=_1712_/A }
C {sky130_stdcells/a211o_4.sym} 7270 -9690 0 0 {name=X_1707_ }
C {devices/lab_pin.sym} 7190 -9560 0 0 {name=p1606 lab=_1731_/B }
C {devices/lab_pin.sym} 7190 -9520 0 0 {name=p1607 lab=_1566_/X }
C {devices/lab_pin.sym} 7190 -9480 0 0 {name=p1608 lab=_1661_/C }
C {devices/lab_pin.sym} 7350 -9520 0 1 {name=p1609 lab=_1569_/X }
C {sky130_stdcells/o21a_4.sym} 7270 -9520 0 0 {name=X_1569_ }
C {devices/lab_pin.sym} 7180 -9380 0 0 {name=p1610 lab=_2477_/CLK }
C {devices/lab_pin.sym} 7180 -9360 0 0 {name=p1611 lab=_2086_/X }
C {devices/lab_pin.sym} 7360 -9380 0 1 {name=p1612 lab=_1991_/B }
C {sky130_stdcells/dfxtp_4.sym} 7270 -9370 0 0 {name=X_2472_ }
C {devices/lab_pin.sym} 7180 -9240 0 0 {name=p1613 lab=_2519_/CLK }
C {devices/lab_pin.sym} 7180 -9220 0 0 {name=p1614 lab=_1905_/Y }
C {devices/lab_pin.sym} 7360 -9240 0 1 {name=p1615 lab=_2541_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7270 -9230 0 0 {name=X_2541_ }
C {devices/lab_pin.sym} 7180 -9100 0 0 {name=p1616 lab=_2581_/CLK }
C {devices/lab_pin.sym} 7180 -9080 0 0 {name=p1617 lab=_1480_/Y }
C {devices/lab_pin.sym} 7360 -9100 0 1 {name=p1618 lab=_1438_/C }
C {sky130_stdcells/dfxtp_4.sym} 7270 -9090 0 0 {name=X_2610_ }
C {devices/lab_pin.sym} 7210 -8970 0 0 {name=p1619 lab=_1352_/X }
C {devices/lab_pin.sym} 7210 -8930 0 0 {name=p1620 lab=_1353_/Y }
C {devices/lab_pin.sym} 7330 -8950 0 1 {name=p1621 lab=_1354_/Y }
C {sky130_stdcells/nand2_4.sym} 7270 -8950 0 0 {name=X_1354_ }
C {devices/lab_pin.sym} 7190 -8860 0 0 {name=p1622 lab=_1225_/X }
C {devices/lab_pin.sym} 7190 -8820 0 0 {name=p1623 lab=_1226_/Y }
C {devices/lab_pin.sym} 7190 -8780 0 0 {name=p1624 lab=_1257_/X }
C {devices/lab_pin.sym} 7190 -8740 0 0 {name=p1625 lab=_1246_/Y }
C {devices/lab_pin.sym} 7190 -8700 0 0 {name=p1626 lab=_1256_/Y }
C {devices/lab_pin.sym} 7350 -8780 0 1 {name=p1627 lab=_1286_/C }
C {sky130_stdcells/o41a_4.sym} 7270 -8780 0 0 {name=X_1285_ }
C {devices/lab_pin.sym} 7230 -8620 0 0 {name=p1628 lab=_2335_/B }
C {devices/lab_pin.sym} 7310 -8620 0 1 {name=p1629 lab=_1423_/Y }
C {sky130_stdcells/inv_2.sym} 7270 -8620 0 0 {name=X_1423_ }
C {devices/lab_pin.sym} 7230 -8500 0 0 {name=p1630 lab=clkbuf_3_5_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 7310 -8500 0 1 {name=p1631 lab=_2581_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 7270 -8500 0 0 {name=Xclkbuf_4_10_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 7210 -8400 0 0 {name=p1632 lab=_1979_/A }
C {devices/lab_pin.sym} 7210 -8360 0 0 {name=p1633 lab=_2496_/Q }
C {devices/lab_pin.sym} 7210 -8320 0 0 {name=p1634 lab=_2497_/Q }
C {devices/lab_pin.sym} 7330 -8360 0 1 {name=p1635 lab=_1978_/B }
C {sky130_stdcells/nand3_4.sym} 7270 -8360 0 0 {name=X_1972_ }
C {devices/lab_pin.sym} 7180 -8220 0 0 {name=p1636 lab=_2457_/CLK }
C {devices/lab_pin.sym} 7180 -8200 0 0 {name=p1637 lab=_2109_/X }
C {devices/lab_pin.sym} 7360 -8220 0 1 {name=p1638 lab=_2455_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7270 -8210 0 0 {name=X_2455_ }
C {devices/lab_pin.sym} 7180 -8080 0 0 {name=p1639 lab=_2506_/CLK }
C {devices/lab_pin.sym} 7180 -8060 0 0 {name=p1640 lab=_2524_/D }
C {devices/lab_pin.sym} 7360 -8080 0 1 {name=p1641 lab=MACRO_RD_SELECT[1] }
C {sky130_stdcells/dfxtp_4.sym} 7270 -8070 0 0 {name=X_2524_ }
C {devices/lab_pin.sym} 7230 -7940 0 0 {name=p1642 lab=_1336_/Y }
C {devices/lab_pin.sym} 7310 -7940 0 1 {name=p1643 lab=_1337_/Y }
C {sky130_stdcells/inv_2.sym} 7270 -7940 0 0 {name=X_1337_ }
C {devices/lab_pin.sym} 7230 -7820 0 0 {name=p1644 lab=_1232_/D }
C {devices/lab_pin.sym} 7310 -7820 0 1 {name=p1645 lab=_1409_/C }
C {sky130_stdcells/buf_2.sym} 7270 -7820 0 0 {name=X_1406_ }
C {devices/lab_pin.sym} 7180 -7700 0 0 {name=p1646 lab=_2570_/CLK }
C {devices/lab_pin.sym} 7180 -7680 0 0 {name=p1647 lab=_2329_/Y }
C {devices/lab_pin.sym} 7360 -7700 0 1 {name=p1648 lab=_2386_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7270 -7690 0 0 {name=X_2386_ }
C {devices/lab_pin.sym} 7210 -7570 0 0 {name=p1649 lab=_1268_/A }
C {devices/lab_pin.sym} 7210 -7530 0 0 {name=p1650 lab=_1719_/A }
C {devices/lab_pin.sym} 7330 -7550 0 1 {name=p1651 lab=_1268_/Y }
C {sky130_stdcells/nand2_4.sym} 7270 -7550 0 0 {name=X_1268_ }
C {devices/lab_pin.sym} 7190 -7440 0 0 {name=p1652 lab=_1194_/A }
C {devices/lab_pin.sym} 7190 -7400 0 0 {name=p1653 lab=_1179_/X }
C {devices/lab_pin.sym} 7190 -7360 0 0 {name=p1654 lab=_1198_/X }
C {devices/lab_pin.sym} 7350 -7400 0 1 {name=p1655 lab=_1199_/Y }
C {sky130_stdcells/o21ai_4.sym} 7270 -7400 0 0 {name=X_1199_ }
C {devices/lab_pin.sym} 7190 -7280 0 0 {name=p1656 lab=_1726_/A }
C {devices/lab_pin.sym} 7190 -7240 0 0 {name=p1657 lab=_2169_/Y }
C {devices/lab_pin.sym} 7190 -7200 0 0 {name=p1658 lab=_2170_/Y }
C {devices/lab_pin.sym} 7350 -7240 0 1 {name=p1659 lab=_2438_/D }
C {sky130_stdcells/o21ai_4.sym} 7270 -7240 0 0 {name=X_2171_ }
C {devices/lab_pin.sym} 7230 -7100 0 0 {name=p1660 lab=_1555_/A }
C {devices/lab_pin.sym} 7310 -7100 0 1 {name=p1661 lab=_2298_/B }
C {sky130_stdcells/buf_2.sym} 7270 -7100 0 0 {name=X_2240_ }
C {devices/lab_pin.sym} 7230 -6980 0 0 {name=p1662 lab=_1874_/A }
C {devices/lab_pin.sym} 7310 -6980 0 1 {name=p1663 lab=_1891_/A }
C {sky130_stdcells/buf_2.sym} 7270 -6980 0 0 {name=X_1886_ }
C {devices/lab_pin.sym} 7210 -6870 0 0 {name=p1664 lab=_1952_/A }
C {devices/lab_pin.sym} 7210 -6830 0 0 {name=p1665 lab=_2518_/Q }
C {devices/lab_pin.sym} 7330 -6850 0 1 {name=p1666 lab=_1955_/X }
C {sky130_stdcells/and2_4.sym} 7270 -6850 0 0 {name=X_1955_ }
C {devices/lab_pin.sym} 7180 -6720 0 0 {name=p1667 lab=_2550_/CLK }
C {devices/lab_pin.sym} 7180 -6700 0 0 {name=p1668 lab=_2438_/D }
C {devices/lab_pin.sym} 7360 -6720 0 1 {name=p1669 lab=_2170_/B }
C {sky130_stdcells/dfxtp_4.sym} 7270 -6710 0 0 {name=X_2438_ }
C {devices/lab_pin.sym} 7180 -6580 0 0 {name=p1670 lab=_2638_/CLK }
C {devices/lab_pin.sym} 7180 -6560 0 0 {name=p1671 lab=_1959_/X }
C {devices/lab_pin.sym} 7360 -6580 0 1 {name=p1672 lab=DATA_TO_HASH[0] }
C {sky130_stdcells/dfxtp_4.sym} 7270 -6570 0 0 {name=X_2507_ }
C {devices/lab_pin.sym} 7180 -6440 0 0 {name=p1673 lab=_2370_/CLK }
C {devices/lab_pin.sym} 7180 -6420 0 0 {name=p1674 lab=_2369_/D }
C {devices/lab_pin.sym} 7360 -6440 0 1 {name=p1675 lab=_2369_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7270 -6430 0 0 {name=X_2369_ }
C {sky130_stdcells/decap_3.sym} 7270 -6270 0 0 {name=XPHY_126 }
C {sky130_stdcells/decap_3.sym} 7270 -6090 0 0 {name=XPHY_115 }
C {sky130_stdcells/decap_3.sym} 7270 -5910 0 0 {name=XPHY_104 }
C {sky130_stdcells/decap_3.sym} 7270 -5730 0 0 {name=XPHY_6 }
C {devices/lab_pin.sym} 7230 -5580 0 0 {name=p1676 lab=_1739_/Y }
C {devices/lab_pin.sym} 7310 -5580 0 1 {name=p1677 lab=_1740_/Y }
C {sky130_stdcells/inv_2.sym} 7270 -5580 0 0 {name=X_1740_ }
C {devices/lab_pin.sym} 7210 -5480 0 0 {name=p1678 lab=_1571_/A }
C {devices/lab_pin.sym} 7210 -5440 0 0 {name=p1679 lab=_1660_/A }
C {devices/lab_pin.sym} 7210 -5400 0 0 {name=p1680 lab=_2234_/D }
C {devices/lab_pin.sym} 7330 -5440 0 1 {name=p1681 lab=_1672_/A }
C {sky130_stdcells/nor3_4.sym} 7270 -5440 0 0 {name=X_1671_ }
C {devices/lab_pin.sym} 7190 -5320 0 0 {name=p1682 lab=_2078_/X }
C {devices/lab_pin.sym} 7190 -5280 0 0 {name=p1683 lab=_1991_/B }
C {devices/lab_pin.sym} 7190 -5240 0 0 {name=p1684 lab=_2063_/A }
C {devices/lab_pin.sym} 7350 -5280 0 1 {name=p1685 lab=_2085_/Y }
C {sky130_stdcells/a21oi_4.sym} 7270 -5280 0 0 {name=X_2085_ }
C {devices/lab_pin.sym} 7230 -5140 0 0 {name=p1686 lab=_1767_/B }
C {devices/lab_pin.sym} 7310 -5140 0 1 {name=p1687 lab=_2223_/Y }
C {sky130_stdcells/inv_2.sym} 7270 -5140 0 0 {name=X_2223_ }
C {devices/lab_pin.sym} 7210 -5030 0 0 {name=p1688 lab=_2151_/A }
C {devices/lab_pin.sym} 7210 -4990 0 0 {name=p1689 lab=_2154_/B }
C {devices/lab_pin.sym} 7330 -5010 0 1 {name=p1690 lab=_2154_/Y }
C {sky130_stdcells/nand2_4.sym} 7270 -5010 0 0 {name=X_2154_ }
C {devices/lab_pin.sym} 7210 -4890 0 0 {name=p1691 lab=_1976_/A }
C {devices/lab_pin.sym} 7210 -4850 0 0 {name=p1692 lab=_1869_/B }
C {devices/lab_pin.sym} 7330 -4870 0 1 {name=p1693 lab=_1869_/Y }
C {sky130_stdcells/nor2_4.sym} 7270 -4870 0 0 {name=X_1869_ }
C {devices/lab_pin.sym} 7210 -4750 0 0 {name=p1694 lab=_1938_/A }
C {devices/lab_pin.sym} 7210 -4710 0 0 {name=p1695 lab=_1937_/Y }
C {devices/lab_pin.sym} 7330 -4730 0 1 {name=p1696 lab=_1938_/Y }
C {sky130_stdcells/nor2_4.sym} 7270 -4730 0 0 {name=X_1938_ }
C {devices/lab_pin.sym} 7190 -4620 0 0 {name=p1697 lab=_1656_/X }
C {devices/lab_pin.sym} 7190 -4580 0 0 {name=p1698 lab=_2619_/Q }
C {devices/lab_pin.sym} 7190 -4540 0 0 {name=p1699 lab=_2166_/A }
C {devices/lab_pin.sym} 7350 -4580 0 1 {name=p1700 lab=_1723_/Y }
C {sky130_stdcells/a21oi_4.sym} 7270 -4580 0 0 {name=X_1723_ }
C {devices/lab_pin.sym} 7210 -4460 0 0 {name=p1701 lab=_1570_/A }
C {devices/lab_pin.sym} 7210 -4420 0 0 {name=p1702 lab=_1568_/A }
C {devices/lab_pin.sym} 7210 -4380 0 0 {name=p1703 lab=_1659_/A }
C {devices/lab_pin.sym} 7330 -4420 0 1 {name=p1704 lab=_1654_/Y }
C {sky130_stdcells/nor3_4.sym} 7270 -4420 0 0 {name=X_1654_ }
C {devices/lab_pin.sym} 7190 -4310 0 0 {name=p1705 lab=_1293_/Y }
C {devices/lab_pin.sym} 7190 -4270 0 0 {name=p1706 lab=_1613_/Y }
C {devices/lab_pin.sym} 7190 -4230 0 0 {name=p1707 lab=_1651_/A }
C {devices/lab_pin.sym} 7190 -4190 0 0 {name=p1708 lab=_1649_/Y }
C {devices/lab_pin.sym} 7350 -4250 0 1 {name=p1709 lab=_2206_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 7270 -4250 0 0 {name=X_2206_ }
C {devices/lab_pin.sym} 7230 -4100 0 0 {name=p1710 lab=_1736_/A }
C {devices/lab_pin.sym} 7310 -4100 0 1 {name=p1711 lab=_1781_/A }
C {sky130_stdcells/buf_2.sym} 7270 -4100 0 0 {name=X_1585_ }
C {devices/lab_pin.sym} 7190 -4000 0 0 {name=p1712 lab=_2060_/Y }
C {devices/lab_pin.sym} 7190 -3960 0 0 {name=p1713 lab=_2058_/X }
C {devices/lab_pin.sym} 7190 -3920 0 0 {name=p1714 lab=_1283_/X }
C {devices/lab_pin.sym} 7350 -3960 0 1 {name=p1715 lab=_2068_/Y }
C {sky130_stdcells/a21oi_4.sym} 7270 -3960 0 0 {name=X_2068_ }
C {devices/lab_pin.sym} 7210 -3830 0 0 {name=p1716 lab=_1221_/A }
C {devices/lab_pin.sym} 7210 -3790 0 0 {name=p1717 lab=_1691_/Y }
C {devices/lab_pin.sym} 7330 -3810 0 1 {name=p1718 lab=_2138_/A }
C {sky130_stdcells/nor2_4.sym} 7270 -3810 0 0 {name=X_2137_ }
C {devices/lab_pin.sym} 7190 -3700 0 0 {name=p1719 lab=_1360_/Y }
C {devices/lab_pin.sym} 7190 -3660 0 0 {name=p1720 lab=_1350_/X }
C {devices/lab_pin.sym} 7190 -3620 0 0 {name=p1721 lab=_1346_/X }
C {devices/lab_pin.sym} 7350 -3660 0 1 {name=p1722 lab=_1370_/Y }
C {sky130_stdcells/o21ai_4.sym} 7270 -3660 0 0 {name=X_1370_ }
C {devices/lab_pin.sym} 7210 -3530 0 0 {name=p1723 lab=_1630_/X }
C {devices/lab_pin.sym} 7210 -3490 0 0 {name=p1724 lab=_1705_/Y }
C {devices/lab_pin.sym} 7330 -3510 0 1 {name=p1725 lab=_1706_/Y }
C {sky130_stdcells/nor2_4.sym} 7270 -3510 0 0 {name=X_1706_ }
C {devices/lab_pin.sym} 7210 -3390 0 0 {name=p1726 lab=_1635_/X }
C {devices/lab_pin.sym} 7210 -3350 0 0 {name=p1727 lab=_1637_/B }
C {devices/lab_pin.sym} 7330 -3370 0 1 {name=p1728 lab=_1637_/Y }
C {sky130_stdcells/nor2_4.sym} 7270 -3370 0 0 {name=X_1637_ }
C {devices/lab_pin.sym} 7230 -3240 0 0 {name=p1729 lab=_1568_/A }
C {devices/lab_pin.sym} 7310 -3240 0 1 {name=p1730 lab=_1661_/C }
C {sky130_stdcells/buf_2.sym} 7270 -3240 0 0 {name=X_1568_ }
C {devices/lab_pin.sym} 7230 -3120 0 0 {name=p1731 lab=_1487_/A }
C {devices/lab_pin.sym} 7310 -3120 0 1 {name=p1732 lab=_1499_/Y }
C {sky130_stdcells/inv_2.sym} 7270 -3120 0 0 {name=X_1499_ }
C {devices/lab_pin.sym} 7180 -3000 0 0 {name=p1733 lab=_2477_/CLK }
C {devices/lab_pin.sym} 7180 -2980 0 0 {name=p1734 lab=_2087_/Y }
C {devices/lab_pin.sym} 7360 -3000 0 1 {name=p1735 lab=_1991_/A }
C {sky130_stdcells/dfxtp_4.sym} 7270 -2990 0 0 {name=X_2471_ }
C {devices/lab_pin.sym} 7180 -2860 0 0 {name=p1736 lab=_2519_/CLK }
C {devices/lab_pin.sym} 7180 -2840 0 0 {name=p1737 lab=_2540_/D }
C {devices/lab_pin.sym} 7360 -2860 0 1 {name=p1738 lab=_2540_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7270 -2850 0 0 {name=X_2540_ }
C {devices/lab_pin.sym} 7230 -2720 0 0 {name=p1739 lab=_1422_/A }
C {devices/lab_pin.sym} 7310 -2720 0 1 {name=p1740 lab=_1445_/D }
C {sky130_stdcells/buf_2.sym} 7270 -2720 0 0 {name=X_1422_ }
C {devices/lab_pin.sym} 7210 -2620 0 0 {name=p1741 lab=_1324_/X }
C {devices/lab_pin.sym} 7210 -2580 0 0 {name=p1742 lab=_2628_/Q }
C {devices/lab_pin.sym} 7210 -2540 0 0 {name=p1743 lab=_1349_/A }
C {devices/lab_pin.sym} 7330 -2580 0 1 {name=p1744 lab=_1353_/Y }
C {sky130_stdcells/nand3_4.sym} 7270 -2580 0 0 {name=X_1353_ }
C {devices/lab_pin.sym} 7230 -2440 0 0 {name=p1745 lab=_1283_/X }
C {devices/lab_pin.sym} 7310 -2440 0 1 {name=p1746 lab=_1284_/X }
C {sky130_stdcells/buf_2.sym} 7270 -2440 0 0 {name=X_1284_ }
C {devices/lab_pin.sym} 7210 -2330 0 0 {name=p1747 lab=_1971_/A }
C {devices/lab_pin.sym} 7210 -2290 0 0 {name=p1748 lab=_2503_/Q }
C {devices/lab_pin.sym} 7330 -2310 0 1 {name=p1749 lab=_1971_/X }
C {sky130_stdcells/and2_4.sym} 7270 -2310 0 0 {name=X_1971_ }
C {devices/lab_pin.sym} 7180 -2180 0 0 {name=p1750 lab=_2457_/CLK }
C {devices/lab_pin.sym} 7180 -2160 0 0 {name=p1751 lab=_2454_/D }
C {devices/lab_pin.sym} 7360 -2180 0 1 {name=p1752 lab=_2109_/B }
C {sky130_stdcells/dfxtp_4.sym} 7270 -2170 0 0 {name=X_2454_ }
C {devices/lab_pin.sym} 7230 -2040 0 0 {name=p1753 lab=_1232_/A }
C {devices/lab_pin.sym} 7310 -2040 0 1 {name=p1754 lab=_1409_/A }
C {sky130_stdcells/buf_2.sym} 7270 -2040 0 0 {name=X_1405_ }
C {devices/lab_pin.sym} 7180 -1920 0 0 {name=p1755 lab=_2570_/CLK }
C {devices/lab_pin.sym} 7180 -1900 0 0 {name=p1756 lab=_2385_/D }
C {devices/lab_pin.sym} 7360 -1920 0 1 {name=p1757 lab=_2385_/Q }
C {sky130_stdcells/dfxtp_4.sym} 7270 -1910 0 0 {name=X_2385_ }
C {devices/lab_pin.sym} 7180 -1780 0 0 {name=p1758 lab=_2506_/CLK }
C {devices/lab_pin.sym} 7180 -1760 0 0 {name=p1759 lab=_2523_/D }
C {devices/lab_pin.sym} 7360 -1780 0 1 {name=p1760 lab=MACRO_RD_SELECT[0] }
C {sky130_stdcells/dfxtp_4.sym} 7270 -1770 0 0 {name=X_2523_ }
C {devices/lab_pin.sym} 2550 -21930 0 0 {name=p1761 lab=_2648_/Q }
C {devices/lab_pin.sym} 2550 -21890 0 0 {name=p1762 lab=_1180_/Y }
C {devices/lab_pin.sym} 2670 -21910 0 1 {name=p1763 lab=_1198_/X }
C {sky130_stdcells/or2_4.sym} 2610 -21910 0 0 {name=X_1198_ }
C {devices/lab_pin.sym} 2550 -21790 0 0 {name=p1764 lab=_1331_/X }
C {devices/lab_pin.sym} 2550 -21750 0 0 {name=p1765 lab=_1335_/Y }
C {devices/lab_pin.sym} 2670 -21770 0 1 {name=p1766 lab=_1336_/Y }
C {sky130_stdcells/nand2_4.sym} 2610 -21770 0 0 {name=X_1336_ }
C {devices/lab_pin.sym} 2570 -21640 0 0 {name=p1767 lab=_1262_/C }
C {devices/lab_pin.sym} 2650 -21640 0 1 {name=p1768 lab=_1719_/A }
C {sky130_stdcells/inv_2.sym} 2610 -21640 0 0 {name=X_1267_ }
C {devices/lab_pin.sym} 2570 -21520 0 0 {name=p1769 lab=_2347_/X }
C {devices/lab_pin.sym} 2650 -21520 0 1 {name=p1770 lab=clkbuf_0_addressalyzerBlock.SPI_CLK/X }
C {sky130_stdcells/clkbuf_16.sym} 2610 -21520 0 0 {name=Xclkbuf_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 2550 -21410 0 0 {name=p1771 lab=_1762_/A }
C {devices/lab_pin.sym} 2550 -21370 0 0 {name=p1772 lab=_2170_/B }
C {devices/lab_pin.sym} 2670 -21390 0 1 {name=p1773 lab=_2170_/Y }
C {sky130_stdcells/nand2_4.sym} 2610 -21390 0 0 {name=X_2170_ }
C {devices/lab_pin.sym} 2550 -21270 0 0 {name=p1774 lab=_1952_/A }
C {devices/lab_pin.sym} 2550 -21230 0 0 {name=p1775 lab=_2519_/Q }
C {devices/lab_pin.sym} 2670 -21250 0 1 {name=p1776 lab=_1954_/X }
C {sky130_stdcells/and2_4.sym} 2610 -21250 0 0 {name=X_1954_ }
C {devices/lab_pin.sym} 2570 -21120 0 0 {name=p1777 lab=clkbuf_2_1_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 2650 -21120 0 1 {name=p1778 lab=clkbuf_2_1_0_addressalyzerBlock.SPI_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 2610 -21120 0 0 {name=Xclkbuf_2_1_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 2550 -21010 0 0 {name=p1779 lab=_1885_/A }
C {devices/lab_pin.sym} 2550 -20970 0 0 {name=p1780 lab=_2563_/Q }
C {devices/lab_pin.sym} 2670 -20990 0 1 {name=p1781 lab=_1885_/X }
C {sky130_stdcells/and2_4.sym} 2610 -20990 0 0 {name=X_1885_ }
C {devices/lab_pin.sym} 2520 -20860 0 0 {name=p1782 lab=_2372_/CLK }
C {devices/lab_pin.sym} 2520 -20840 0 0 {name=p1783 lab=_2367_/Q }
C {devices/lab_pin.sym} 2700 -20860 0 1 {name=p1784 lab=_2369_/D }
C {sky130_stdcells/dfxtp_4.sym} 2610 -20850 0 0 {name=X_2368_ }
C {devices/lab_pin.sym} 2570 -20720 0 0 {name=p1785 lab=clkbuf_4_7_0_m1_clk_local/A }
C {devices/lab_pin.sym} 2650 -20720 0 1 {name=p1786 lab=_2470_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2610 -20720 0 0 {name=Xclkbuf_4_7_0_m1_clk_local }
C {devices/lab_pin.sym} 2520 -20600 0 0 {name=p1787 lab=_2590_/CLK }
C {devices/lab_pin.sym} 2520 -20580 0 0 {name=p1788 lab=_2193_/Y }
C {devices/lab_pin.sym} 2700 -20600 0 1 {name=p1789 lab=_2437_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2610 -20590 0 0 {name=X_2437_ }
C {devices/lab_pin.sym} 2520 -20460 0 0 {name=p1790 lab=_2506_/CLK }
C {devices/lab_pin.sym} 2520 -20440 0 0 {name=p1791 lab=_2506_/D }
C {devices/lab_pin.sym} 2700 -20460 0 1 {name=p1792 lab=_1968_/B }
C {sky130_stdcells/dfxtp_4.sym} 2610 -20450 0 0 {name=X_2506_ }
C {sky130_stdcells/decap_3.sym} 2610 -20290 0 0 {name=XPHY_116 }
C {sky130_stdcells/decap_3.sym} 2610 -20110 0 0 {name=XPHY_105 }
C {devices/lab_pin.sym} 2550 -19970 0 0 {name=p1793 lab=_1319_/A }
C {devices/lab_pin.sym} 2550 -19930 0 0 {name=p1794 lab=_1318_/Y }
C {devices/lab_pin.sym} 2670 -19950 0 1 {name=p1795 lab=_1319_/Y }
C {sky130_stdcells/nand2_4.sym} 2610 -19950 0 0 {name=X_1319_ }
C {devices/lab_pin.sym} 2530 -19840 0 0 {name=p1796 lab=_2268_/Y }
C {devices/lab_pin.sym} 2530 -19800 0 0 {name=p1797 lab=_2291_/X }
C {devices/lab_pin.sym} 2530 -19760 0 0 {name=p1798 lab=_2298_/Y }
C {devices/lab_pin.sym} 2690 -19800 0 1 {name=p1799 lab=_2299_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -19800 0 0 {name=X_2299_ }
C {sky130_stdcells/decap_3.sym} 2610 -19630 0 0 {name=XPHY_127 }
C {sky130_stdcells/decap_3.sym} 2610 -19450 0 0 {name=XPHY_7 }
C {devices/lab_pin.sym} 2570 -19300 0 0 {name=p1800 lab=_1669_/Y }
C {devices/lab_pin.sym} 2650 -19300 0 1 {name=p1801 lab=_2234_/D }
C {sky130_stdcells/inv_2.sym} 2610 -19300 0 0 {name=X_1670_ }
C {devices/lab_pin.sym} 2530 -19200 0 0 {name=p1802 lab=_2219_/Y }
C {devices/lab_pin.sym} 2530 -19160 0 0 {name=p1803 lab=_2221_/Y }
C {devices/lab_pin.sym} 2530 -19120 0 0 {name=p1804 lab=_1628_/X }
C {devices/lab_pin.sym} 2690 -19160 0 1 {name=p1805 lab=_2222_/X }
C {sky130_stdcells/a21o_4.sym} 2610 -19160 0 0 {name=X_2222_ }
C {devices/lab_pin.sym} 2550 -19040 0 0 {name=p1806 lab=_2084_/A }
C {devices/lab_pin.sym} 2550 -19000 0 0 {name=p1807 lab=_2044_/B }
C {devices/lab_pin.sym} 2550 -18960 0 0 {name=p1808 lab=_2084_/C }
C {devices/lab_pin.sym} 2670 -19000 0 1 {name=p1809 lab=_2473_/D }
C {sky130_stdcells/and3_4.sym} 2610 -19000 0 0 {name=X_2084_ }
C {devices/lab_pin.sym} 2550 -18880 0 0 {name=p1810 lab=_2151_/Y }
C {devices/lab_pin.sym} 2550 -18840 0 0 {name=p1811 lab=_1708_/X }
C {devices/lab_pin.sym} 2550 -18800 0 0 {name=p1812 lab=_2153_/C }
C {devices/lab_pin.sym} 2670 -18840 0 1 {name=p1813 lab=_2153_/Y }
C {sky130_stdcells/nand3_4.sym} 2610 -18840 0 0 {name=X_2153_ }
C {devices/lab_pin.sym} 2570 -18700 0 0 {name=p1814 lab=_1937_/A }
C {devices/lab_pin.sym} 2650 -18700 0 1 {name=p1815 lab=_1937_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -18700 0 0 {name=X_1937_ }
C {devices/lab_pin.sym} 2550 -18590 0 0 {name=p1816 lab=_2567_/Q }
C {devices/lab_pin.sym} 2550 -18550 0 0 {name=p1817 lab=_1976_/B }
C {devices/lab_pin.sym} 2670 -18570 0 1 {name=p1818 lab=_1869_/B }
C {sky130_stdcells/xnor2_4.sym} 2610 -18570 0 0 {name=X_1868_ }
C {devices/lab_pin.sym} 2570 -18440 0 0 {name=p1819 lab=_1555_/A }
C {devices/lab_pin.sym} 2650 -18440 0 1 {name=p1820 lab=_1799_/X }
C {sky130_stdcells/buf_2.sym} 2610 -18440 0 0 {name=X_1799_ }
C {devices/lab_pin.sym} 2530 -18340 0 0 {name=p1821 lab=_1700_/X }
C {devices/lab_pin.sym} 2530 -18300 0 0 {name=p1822 lab=_1720_/Y }
C {devices/lab_pin.sym} 2530 -18260 0 0 {name=p1823 lab=_1721_/Y }
C {devices/lab_pin.sym} 2690 -18300 0 1 {name=p1824 lab=_1722_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -18300 0 0 {name=X_1722_ }
C {devices/lab_pin.sym} 2530 -18180 0 0 {name=p1825 lab=_1642_/Y }
C {devices/lab_pin.sym} 2530 -18140 0 0 {name=p1826 lab=_1646_/X }
C {devices/lab_pin.sym} 2530 -18100 0 0 {name=p1827 lab=_1652_/X }
C {devices/lab_pin.sym} 2690 -18140 0 1 {name=p1828 lab=_1653_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -18140 0 0 {name=X_1653_ }
C {devices/lab_pin.sym} 2570 -18000 0 0 {name=p1829 lab=_1219_/X }
C {devices/lab_pin.sym} 2650 -18000 0 1 {name=p1830 lab=_1736_/A }
C {sky130_stdcells/buf_2.sym} 2610 -18000 0 0 {name=X_1584_ }
C {devices/lab_pin.sym} 2530 -17900 0 0 {name=p1831 lab=_2202_/X }
C {devices/lab_pin.sym} 2530 -17860 0 0 {name=p1832 lab=_2204_/X }
C {devices/lab_pin.sym} 2530 -17820 0 0 {name=p1833 lab=_1701_/A }
C {devices/lab_pin.sym} 2690 -17860 0 1 {name=p1834 lab=_2205_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -17860 0 0 {name=X_2205_ }
C {devices/lab_pin.sym} 2550 -17740 0 0 {name=p1835 lab=_2063_/A }
C {devices/lab_pin.sym} 2550 -17700 0 0 {name=p1836 lab=_1993_/B }
C {devices/lab_pin.sym} 2550 -17660 0 0 {name=p1837 lab=_2066_/Y }
C {devices/lab_pin.sym} 2670 -17700 0 1 {name=p1838 lab=_2478_/D }
C {sky130_stdcells/nor3_4.sym} 2610 -17700 0 0 {name=X_2067_ }
C {devices/lab_pin.sym} 2570 -17560 0 0 {name=p1839 lab=_2253_/C }
C {devices/lab_pin.sym} 2650 -17560 0 1 {name=p1840 lab=_2136_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -17560 0 0 {name=X_2136_ }
C {devices/lab_pin.sym} 2570 -17440 0 0 {name=p1841 lab=_2417_/Q }
C {devices/lab_pin.sym} 2650 -17440 0 1 {name=p1842 lab=_1705_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -17440 0 0 {name=X_1705_ }
C {devices/lab_pin.sym} 2550 -17340 0 0 {name=p1843 lab=_1428_/B }
C {devices/lab_pin.sym} 2550 -17300 0 0 {name=p1844 lab=_1428_/C }
C {devices/lab_pin.sym} 2550 -17260 0 0 {name=p1845 lab=_1428_/D }
C {devices/lab_pin.sym} 2670 -17300 0 1 {name=p1846 lab=_1568_/A }
C {sky130_stdcells/nand3_4.sym} 2610 -17300 0 0 {name=X_1567_ }
C {devices/lab_pin.sym} 2570 -17160 0 0 {name=p1847 lab=_1636_/A }
C {devices/lab_pin.sym} 2650 -17160 0 1 {name=p1848 lab=_1637_/B }
C {sky130_stdcells/inv_2.sym} 2610 -17160 0 0 {name=X_1636_ }
C {devices/lab_pin.sym} 2570 -17040 0 0 {name=p1849 lab=_2119_/A }
C {devices/lab_pin.sym} 2650 -17040 0 1 {name=p1850 lab=_2123_/A }
C {sky130_stdcells/inv_2.sym} 2610 -17040 0 0 {name=X_2119_ }
C {devices/lab_pin.sym} 2530 -16940 0 0 {name=p1851 lab=_2253_/C }
C {devices/lab_pin.sym} 2530 -16900 0 0 {name=p1852 lab=_2333_/B }
C {devices/lab_pin.sym} 2530 -16860 0 0 {name=p1853 lab=_1462_/X }
C {devices/lab_pin.sym} 2690 -16900 0 1 {name=p1854 lab=_1498_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -16900 0 0 {name=X_1498_ }
C {devices/lab_pin.sym} 2570 -16760 0 0 {name=p1855 lab=clkbuf_3_7_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 2650 -16760 0 1 {name=p1856 lab=_2457_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2610 -16760 0 0 {name=Xclkbuf_4_15_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 2520 -16640 0 0 {name=p1857 lab=_2470_/CLK }
C {devices/lab_pin.sym} 2520 -16620 0 0 {name=p1858 lab=_2088_/X }
C {devices/lab_pin.sym} 2700 -16640 0 1 {name=p1859 lab=HASH_EN }
C {sky130_stdcells/dfxtp_4.sym} 2610 -16630 0 0 {name=X_2470_ }
C {devices/lab_pin.sym} 2570 -16500 0 0 {name=p1860 lab=_2390_/Q }
C {devices/lab_pin.sym} 2650 -16500 0 1 {name=p1861 lab=_1422_/A }
C {sky130_stdcells/inv_2.sym} 2610 -16500 0 0 {name=X_1421_ }
C {devices/lab_pin.sym} 2570 -16380 0 0 {name=p1862 lab=_2363_/Q }
C {devices/lab_pin.sym} 2650 -16380 0 1 {name=p1863 lab=_1283_/X }
C {sky130_stdcells/buf_2.sym} 2610 -16380 0 0 {name=X_1283_ }
C {devices/lab_pin.sym} 2530 -16280 0 0 {name=p1864 lab=_2628_/Q }
C {devices/lab_pin.sym} 2530 -16240 0 0 {name=p1865 lab=_1356_/A }
C {devices/lab_pin.sym} 2530 -16200 0 0 {name=p1866 lab=_1306_/X }
C {devices/lab_pin.sym} 2690 -16240 0 1 {name=p1867 lab=_1352_/X }
C {sky130_stdcells/o21a_4.sym} 2610 -16240 0 0 {name=X_1352_ }
C {devices/lab_pin.sym} 2520 -16100 0 0 {name=p1868 lab=_2590_/CLK }
C {devices/lab_pin.sym} 2520 -16080 0 0 {name=p1869 lab=_1587_/Y }
C {devices/lab_pin.sym} 2700 -16100 0 1 {name=p1870 lab=_1428_/B }
C {sky130_stdcells/dfxtp_4.sym} 2610 -16090 0 0 {name=X_2599_ }
C {devices/lab_pin.sym} 2570 -15960 0 0 {name=p1871 lab=_1619_/A }
C {devices/lab_pin.sym} 2650 -15960 0 1 {name=p1872 lab=_1620_/B }
C {sky130_stdcells/inv_2.sym} 2610 -15960 0 0 {name=X_1619_ }
C {devices/lab_pin.sym} 2550 -15850 0 0 {name=p1873 lab=_1971_/A }
C {devices/lab_pin.sym} 2550 -15810 0 0 {name=p1874 lab=_2504_/Q }
C {devices/lab_pin.sym} 2670 -15830 0 1 {name=p1875 lab=_2500_/D }
C {sky130_stdcells/and2_4.sym} 2610 -15830 0 0 {name=X_1970_ }
C {devices/lab_pin.sym} 2520 -15700 0 0 {name=p1876 lab=_2528_/CLK }
C {devices/lab_pin.sym} 2520 -15680 0 0 {name=p1877 lab=_2522_/D }
C {devices/lab_pin.sym} 2700 -15700 0 1 {name=p1878 lab=_1951_/B }
C {sky130_stdcells/dfxtp_4.sym} 2610 -15690 0 0 {name=X_2522_ }
C {devices/lab_pin.sym} 2570 -15560 0 0 {name=p1879 lab=clkbuf_3_7_0_m1_clk_local/X }
C {devices/lab_pin.sym} 2650 -15560 0 1 {name=p1880 lab=_2496_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2610 -15560 0 0 {name=Xclkbuf_4_15_0_m1_clk_local }
C {devices/lab_pin.sym} 2520 -15440 0 0 {name=p1881 lab=_2550_/CLK }
C {devices/lab_pin.sym} 2520 -15420 0 0 {name=p1882 lab=_2384_/D }
C {devices/lab_pin.sym} 2700 -15440 0 1 {name=p1883 lab=_2384_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2610 -15430 0 0 {name=X_2384_ }
C {devices/lab_pin.sym} 2570 -15300 0 0 {name=p1884 lab=_1404_/A }
C {devices/lab_pin.sym} 2650 -15300 0 1 {name=p1885 lab=_1404_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -15300 0 0 {name=X_1404_ }
C {devices/lab_pin.sym} 2550 -15210 0 0 {name=p1886 lab=_1335_/A }
C {devices/lab_pin.sym} 2550 -15170 0 0 {name=p1887 lab=_1333_/Y }
C {devices/lab_pin.sym} 2550 -15130 0 0 {name=p1888 lab=_1335_/C }
C {devices/lab_pin.sym} 2550 -15090 0 0 {name=p1889 lab=_1335_/D }
C {devices/lab_pin.sym} 2670 -15150 0 1 {name=p1890 lab=_1335_/Y }
C {sky130_stdcells/nand4_4.sym} 2610 -15150 0 0 {name=X_1335_ }
C {devices/lab_pin.sym} 2520 -15000 0 0 {name=p1891 lab=_2390_/CLK }
C {devices/lab_pin.sym} 2520 -14980 0 0 {name=p1892 lab=_2111_/Y }
C {devices/lab_pin.sym} 2700 -15000 0 1 {name=p1893 lab=_2099_/C }
C {sky130_stdcells/dfxtp_4.sym} 2610 -14990 0 0 {name=X_2453_ }
C {devices/lab_pin.sym} 2530 -14880 0 0 {name=p1894 lab=_1195_/Y }
C {devices/lab_pin.sym} 2530 -14840 0 0 {name=p1895 lab=_1187_/X }
C {devices/lab_pin.sym} 2530 -14800 0 0 {name=p1896 lab=_1196_/Y }
C {devices/lab_pin.sym} 2690 -14840 0 1 {name=p1897 lab=_1197_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -14840 0 0 {name=X_1197_ }
C {devices/lab_pin.sym} 2550 -14730 0 0 {name=p1898 lab=_1277_/D }
C {devices/lab_pin.sym} 2550 -14690 0 0 {name=p1899 lab=_1265_/Y }
C {devices/lab_pin.sym} 2550 -14650 0 0 {name=p1900 lab=_1224_/A }
C {devices/lab_pin.sym} 2550 -14610 0 0 {name=p1901 lab=_1249_/Y }
C {devices/lab_pin.sym} 2670 -14670 0 1 {name=p1902 lab=_1268_/A }
C {sky130_stdcells/nand4_4.sym} 2610 -14670 0 0 {name=X_1266_ }
C {devices/lab_pin.sym} 2550 -14530 0 0 {name=p1903 lab=_1885_/A }
C {devices/lab_pin.sym} 2550 -14490 0 0 {name=p1904 lab=_2564_/Q }
C {devices/lab_pin.sym} 2670 -14510 0 1 {name=p1905 lab=_2556_/D }
C {sky130_stdcells/and2_4.sym} 2610 -14510 0 0 {name=X_1884_ }
C {devices/lab_pin.sym} 2550 -14390 0 0 {name=p1906 lab=_1952_/A }
C {devices/lab_pin.sym} 2550 -14350 0 0 {name=p1907 lab=_1953_/B }
C {devices/lab_pin.sym} 2670 -14370 0 1 {name=p1908 lab=_1953_/X }
C {sky130_stdcells/and2_4.sym} 2610 -14370 0 0 {name=X_1953_ }
C {devices/lab_pin.sym} 2520 -14240 0 0 {name=p1909 lab=_2641_/CLK }
C {devices/lab_pin.sym} 2520 -14220 0 0 {name=p1910 lab=_1963_/Y }
C {devices/lab_pin.sym} 2700 -14240 0 1 {name=p1911 lab=_2505_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2610 -14230 0 0 {name=X_2505_ }
C {devices/lab_pin.sym} 2520 -14100 0 0 {name=p1912 lab=_2367_/CLK }
C {devices/lab_pin.sym} 2520 -14080 0 0 {name=p1913 lab=_1864_/A }
C {devices/lab_pin.sym} 2700 -14100 0 1 {name=p1914 lab=_2367_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2610 -14090 0 0 {name=X_2367_ }
C {devices/lab_pin.sym} 2520 -13960 0 0 {name=p1915 lab=_2590_/CLK }
C {devices/lab_pin.sym} 2520 -13940 0 0 {name=p1916 lab=_2215_/Y }
C {devices/lab_pin.sym} 2700 -13960 0 1 {name=p1917 lab=_2436_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2610 -13950 0 0 {name=X_2436_ }
C {devices/lab_pin.sym} 2550 -13850 0 0 {name=p1918 lab=_1318_/A }
C {devices/lab_pin.sym} 2550 -13810 0 0 {name=p1919 lab=_1318_/B }
C {devices/lab_pin.sym} 2550 -13770 0 0 {name=p1920 lab=_1316_/B }
C {devices/lab_pin.sym} 2550 -13730 0 0 {name=p1921 lab=_1316_/D }
C {devices/lab_pin.sym} 2670 -13790 0 1 {name=p1922 lab=_1318_/Y }
C {sky130_stdcells/nand4_4.sym} 2610 -13790 0 0 {name=X_1318_ }
C {devices/lab_pin.sym} 2550 -13660 0 0 {name=p1923 lab=_2304_/A }
C {devices/lab_pin.sym} 2550 -13620 0 0 {name=p1924 lab=_2298_/B }
C {devices/lab_pin.sym} 2550 -13580 0 0 {name=p1925 lab=ID_toHost }
C {devices/lab_pin.sym} 2670 -13620 0 1 {name=p1926 lab=_2298_/Y }
C {sky130_stdcells/nand3_4.sym} 2610 -13620 0 0 {name=X_2298_ }
C {sky130_stdcells/decap_3.sym} 2610 -13450 0 0 {name=XPHY_128 }
C {sky130_stdcells/decap_3.sym} 2610 -13270 0 0 {name=XPHY_117 }
C {sky130_stdcells/decap_3.sym} 2610 -13090 0 0 {name=XPHY_106 }
C {devices/lab_pin.sym} 2570 -12940 0 0 {name=p1927 lab=_1249_/A }
C {devices/lab_pin.sym} 2650 -12940 0 1 {name=p1928 lab=_1249_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -12940 0 0 {name=X_1249_ }
C {sky130_stdcells/decap_3.sym} 2610 -12790 0 0 {name=XPHY_8 }
C {devices/lab_pin.sym} 2530 -12660 0 0 {name=p1929 lab=_1948_/Y }
C {devices/lab_pin.sym} 2530 -12620 0 0 {name=p1930 lab=_1624_/X }
C {devices/lab_pin.sym} 2530 -12580 0 0 {name=p1931 lab=_2220_/Y }
C {devices/lab_pin.sym} 2690 -12620 0 1 {name=p1932 lab=_2221_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -12620 0 0 {name=X_2221_ }
C {devices/lab_pin.sym} 2550 -12490 0 0 {name=p1933 lab=HASH_LED }
C {devices/lab_pin.sym} 2550 -12450 0 0 {name=p1934 lab=_2175_/B }
C {devices/lab_pin.sym} 2670 -12470 0 1 {name=p1935 lab=_2153_/C }
C {sky130_stdcells/nand2_4.sym} 2610 -12470 0 0 {name=X_2152_ }
C {devices/lab_pin.sym} 2530 -12360 0 0 {name=p1936 lab=_2078_/X }
C {devices/lab_pin.sym} 2530 -12320 0 0 {name=p1937 lab=_1991_/B }
C {devices/lab_pin.sym} 2530 -12280 0 0 {name=p1938 lab=_1991_/C }
C {devices/lab_pin.sym} 2690 -12320 0 1 {name=p1939 lab=_2084_/A }
C {sky130_stdcells/a21o_4.sym} 2610 -12320 0 0 {name=X_2083_ }
C {devices/lab_pin.sym} 2550 -12200 0 0 {name=p1940 lab=_1973_/A }
C {devices/lab_pin.sym} 2550 -12160 0 0 {name=p1941 lab=_2497_/Q }
C {devices/lab_pin.sym} 2550 -12120 0 0 {name=p1942 lab=_1980_/B }
C {devices/lab_pin.sym} 2670 -12160 0 1 {name=p1943 lab=_1976_/B }
C {sky130_stdcells/nor3_4.sym} 2610 -12160 0 0 {name=X_1867_ }
C {devices/lab_pin.sym} 2550 -12030 0 0 {name=p1944 lab=_1938_/A }
C {devices/lab_pin.sym} 2550 -11990 0 0 {name=p1945 lab=_1622_/Y }
C {devices/lab_pin.sym} 2670 -12010 0 1 {name=p1946 lab=_2522_/D }
C {sky130_stdcells/nor2_4.sym} 2610 -12010 0 0 {name=X_1936_ }
C {devices/lab_pin.sym} 2530 -11900 0 0 {name=p1947 lab=_1983_/B }
C {devices/lab_pin.sym} 2530 -11860 0 0 {name=p1948 lab=_2576_/Q }
C {devices/lab_pin.sym} 2530 -11820 0 0 {name=p1949 lab=_1797_/X }
C {devices/lab_pin.sym} 2690 -11860 0 1 {name=p1950 lab=_1798_/X }
C {sky130_stdcells/o21a_4.sym} 2610 -11860 0 0 {name=X_1798_ }
C {devices/lab_pin.sym} 2520 -11720 0 0 {name=p1951 lab=_2408_/CLK }
C {devices/lab_pin.sym} 2520 -11700 0 0 {name=p1952 lab=_2419_/D }
C {devices/lab_pin.sym} 2700 -11720 0 1 {name=p1953 lab=_1948_/A }
C {sky130_stdcells/dfxtp_4.sym} 2610 -11710 0 0 {name=X_2419_ }
C {devices/lab_pin.sym} 2530 -11600 0 0 {name=p1954 lab=_1612_/X }
C {devices/lab_pin.sym} 2530 -11560 0 0 {name=p1955 lab=_1349_/Y }
C {devices/lab_pin.sym} 2530 -11520 0 0 {name=p1956 lab=_1656_/X }
C {devices/lab_pin.sym} 2690 -11560 0 1 {name=p1957 lab=_1721_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -11560 0 0 {name=X_1721_ }
C {devices/lab_pin.sym} 2550 -11440 0 0 {name=p1958 lab=_1856_/A }
C {devices/lab_pin.sym} 2550 -11400 0 0 {name=p1959 lab=_2636_/Q }
C {devices/lab_pin.sym} 2550 -11360 0 0 {name=p1960 lab=_1651_/X }
C {devices/lab_pin.sym} 2670 -11400 0 1 {name=p1961 lab=_1652_/X }
C {sky130_stdcells/and3_4.sym} 2610 -11400 0 0 {name=X_1652_ }
C {devices/lab_pin.sym} 2570 -11260 0 0 {name=p1962 lab=_1559_/B }
C {devices/lab_pin.sym} 2650 -11260 0 1 {name=p1963 lab=_1583_/X }
C {sky130_stdcells/buf_2.sym} 2610 -11260 0 0 {name=X_1583_ }
C {devices/lab_pin.sym} 2530 -11160 0 0 {name=p1964 lab=_2120_/X }
C {devices/lab_pin.sym} 2530 -11120 0 0 {name=p1965 lab=_2133_/Y }
C {devices/lab_pin.sym} 2530 -11080 0 0 {name=p1966 lab=_2134_/Y }
C {devices/lab_pin.sym} 2690 -11120 0 1 {name=p1967 lab=_2135_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -11120 0 0 {name=X_2135_ }
C {devices/lab_pin.sym} 2530 -11010 0 0 {name=p1968 lab=_1964_/A }
C {devices/lab_pin.sym} 2530 -10970 0 0 {name=p1969 lab=_1635_/X }
C {devices/lab_pin.sym} 2530 -10930 0 0 {name=p1970 lab=_1632_/Y }
C {devices/lab_pin.sym} 2530 -10890 0 0 {name=p1971 lab=_2203_/Y }
C {devices/lab_pin.sym} 2690 -10950 0 1 {name=p1972 lab=_2204_/X }
C {sky130_stdcells/a211o_4.sym} 2610 -10950 0 0 {name=X_2204_ }
C {devices/lab_pin.sym} 2530 -10820 0 0 {name=p1973 lab=_2060_/Y }
C {devices/lab_pin.sym} 2530 -10780 0 0 {name=p1974 lab=_2058_/X }
C {devices/lab_pin.sym} 2530 -10740 0 0 {name=p1975 lab=_2062_/B }
C {devices/lab_pin.sym} 2690 -10780 0 1 {name=p1976 lab=_2066_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -10780 0 0 {name=X_2066_ }
C {devices/lab_pin.sym} 2550 -10650 0 0 {name=p1977 lab=_1918_/A }
C {devices/lab_pin.sym} 2550 -10610 0 0 {name=p1978 lab=_2539_/Q }
C {devices/lab_pin.sym} 2670 -10630 0 1 {name=p1979 lab=_2533_/D }
C {sky130_stdcells/and2_4.sym} 2610 -10630 0 0 {name=X_1919_ }
C {devices/lab_pin.sym} 2570 -10500 0 0 {name=p1980 lab=_1617_/Y }
C {devices/lab_pin.sym} 2650 -10500 0 1 {name=p1981 lab=_2179_/B }
C {sky130_stdcells/buf_2.sym} 2610 -10500 0 0 {name=X_1704_ }
C {devices/lab_pin.sym} 2570 -10380 0 0 {name=p1982 lab=_1566_/A }
C {devices/lab_pin.sym} 2650 -10380 0 1 {name=p1983 lab=_1566_/X }
C {sky130_stdcells/buf_2.sym} 2610 -10380 0 0 {name=X_1566_ }
C {devices/lab_pin.sym} 2570 -10260 0 0 {name=p1984 lab=_1497_/A }
C {devices/lab_pin.sym} 2650 -10260 0 1 {name=p1985 lab=_2253_/C }
C {sky130_stdcells/buf_2.sym} 2610 -10260 0 0 {name=X_1497_ }
C {devices/lab_pin.sym} 2570 -10140 0 0 {name=p1986 lab=_1703_/A }
C {devices/lab_pin.sym} 2650 -10140 0 1 {name=p1987 lab=_1635_/X }
C {sky130_stdcells/buf_2.sym} 2610 -10140 0 0 {name=X_1635_ }
C {devices/lab_pin.sym} 2550 -10040 0 0 {name=p1988 lab=_2049_/A }
C {devices/lab_pin.sym} 2550 -10000 0 0 {name=p1989 lab=_2006_/B }
C {devices/lab_pin.sym} 2550 -9960 0 0 {name=p1990 lab=_2048_/Y }
C {devices/lab_pin.sym} 2670 -10000 0 1 {name=p1991 lab=_2049_/Y }
C {sky130_stdcells/nand3_4.sym} 2610 -10000 0 0 {name=X_2049_ }
C {devices/lab_pin.sym} 2550 -9890 0 0 {name=p1992 lab=_1590_/B }
C {devices/lab_pin.sym} 2550 -9850 0 0 {name=p1993 lab=_1579_/X }
C {devices/lab_pin.sym} 2550 -9810 0 0 {name=p1994 lab=_1669_/B }
C {devices/lab_pin.sym} 2550 -9770 0 0 {name=p1995 lab=_1694_/X }
C {devices/lab_pin.sym} 2670 -9830 0 1 {name=p1996 lab=_2119_/A }
C {sky130_stdcells/and4_4.sym} 2610 -9830 0 0 {name=X_2118_ }
C {devices/lab_pin.sym} 2550 -9700 0 0 {name=p1997 lab=_1349_/Y }
C {devices/lab_pin.sym} 2550 -9660 0 0 {name=p1998 lab=_1228_/Y }
C {devices/lab_pin.sym} 2550 -9620 0 0 {name=p1999 lab=_1350_/X }
C {devices/lab_pin.sym} 2670 -9660 0 1 {name=p2000 lab=_1356_/A }
C {sky130_stdcells/nor3_4.sym} 2610 -9660 0 0 {name=X_1351_ }
C {devices/lab_pin.sym} 2570 -9520 0 0 {name=p2001 lab=_1420_/A }
C {devices/lab_pin.sym} 2650 -9520 0 1 {name=p2002 lab=_1420_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -9520 0 0 {name=X_1420_ }
C {devices/lab_pin.sym} 2550 -9420 0 0 {name=p2003 lab=_1281_/Y }
C {devices/lab_pin.sym} 2550 -9380 0 0 {name=p2004 lab=_2010_/B }
C {devices/lab_pin.sym} 2550 -9340 0 0 {name=p2005 lab=_1282_/C }
C {devices/lab_pin.sym} 2670 -9380 0 1 {name=p2006 lab=_1282_/X }
C {sky130_stdcells/and3_4.sym} 2610 -9380 0 0 {name=X_1282_ }
C {devices/lab_pin.sym} 2570 -9240 0 0 {name=p2007 lab=_2447_/Q }
C {devices/lab_pin.sym} 2650 -9240 0 1 {name=p2008 lab=_2175_/B }
C {sky130_stdcells/buf_2.sym} 2610 -9240 0 0 {name=X_1618_ }
C {devices/lab_pin.sym} 2570 -9120 0 0 {name=p2009 lab=_1549_/A }
C {devices/lab_pin.sym} 2650 -9120 0 1 {name=p2010 lab=_1549_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -9120 0 0 {name=X_1549_ }
C {devices/lab_pin.sym} 2520 -9000 0 0 {name=p2011 lab=_2598_/CLK }
C {devices/lab_pin.sym} 2520 -8980 0 0 {name=p2012 lab=_2598_/D }
C {devices/lab_pin.sym} 2700 -9000 0 1 {name=p2013 lab=_1426_/A }
C {sky130_stdcells/dfxtp_4.sym} 2610 -8990 0 0 {name=X_2598_ }
C {devices/lab_pin.sym} 2570 -8860 0 0 {name=p2014 lab=clkbuf_2_0_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 2650 -8860 0 1 {name=p2015 lab=clkbuf_4_3_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 2610 -8860 0 0 {name=Xclkbuf_3_1_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 2520 -8740 0 0 {name=p2016 lab=_2641_/CLK }
C {devices/lab_pin.sym} 2520 -8720 0 0 {name=p2017 lab=_1938_/Y }
C {devices/lab_pin.sym} 2700 -8740 0 1 {name=p2018 lab=_2521_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2610 -8730 0 0 {name=X_2521_ }
C {devices/lab_pin.sym} 2520 -8600 0 0 {name=p2019 lab=_2550_/CLK }
C {devices/lab_pin.sym} 2520 -8580 0 0 {name=p2020 lab=_2383_/D }
C {devices/lab_pin.sym} 2700 -8600 0 1 {name=p2021 lab=_2384_/D }
C {sky130_stdcells/dfxtp_4.sym} 2610 -8590 0 0 {name=X_2383_ }
C {devices/lab_pin.sym} 2530 -8480 0 0 {name=p2022 lab=_1231_/B }
C {devices/lab_pin.sym} 2530 -8440 0 0 {name=p2023 lab=_1408_/B }
C {devices/lab_pin.sym} 2530 -8400 0 0 {name=p2024 lab=_1402_/Y }
C {devices/lab_pin.sym} 2690 -8440 0 1 {name=p2025 lab=_1404_/A }
C {sky130_stdcells/o21ai_4.sym} 2610 -8440 0 0 {name=X_1403_ }
C {devices/lab_pin.sym} 2570 -8300 0 0 {name=p2026 lab=_1242_/C }
C {devices/lab_pin.sym} 2650 -8300 0 1 {name=p2027 lab=_1335_/D }
C {sky130_stdcells/buf_2.sym} 2610 -8300 0 0 {name=X_1334_ }
C {devices/lab_pin.sym} 2520 -8180 0 0 {name=p2028 lab=_2570_/CLK }
C {devices/lab_pin.sym} 2520 -8160 0 0 {name=p2029 lab=_2112_/Y }
C {devices/lab_pin.sym} 2700 -8180 0 1 {name=p2030 lab=_2452_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2610 -8170 0 0 {name=X_2452_ }
C {devices/lab_pin.sym} 2550 -8050 0 0 {name=p2031 lab=_1257_/X }
C {devices/lab_pin.sym} 2550 -8010 0 0 {name=p2032 lab=_1260_/Y }
C {devices/lab_pin.sym} 2670 -8030 0 1 {name=p2033 lab=_1265_/Y }
C {sky130_stdcells/nor2_4.sym} 2610 -8030 0 0 {name=X_1265_ }
C {devices/lab_pin.sym} 2530 -7920 0 0 {name=p2034 lab=_1862_/B }
C {devices/lab_pin.sym} 2530 -7880 0 0 {name=p2035 lab=_1216_/B }
C {devices/lab_pin.sym} 2530 -7840 0 0 {name=p2036 lab=_1191_/X }
C {devices/lab_pin.sym} 2690 -7880 0 1 {name=p2037 lab=_1196_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -7880 0 0 {name=X_1196_ }
C {devices/lab_pin.sym} 2570 -7740 0 0 {name=p2038 lab=clkbuf_2_1_0_m1_clk_local/A }
C {devices/lab_pin.sym} 2650 -7740 0 1 {name=p2039 lab=clkbuf_3_1_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 2610 -7740 0 0 {name=Xclkbuf_2_0_0_m1_clk_local }
C {devices/lab_pin.sym} 2550 -7630 0 0 {name=p2040 lab=_1885_/A }
C {devices/lab_pin.sym} 2550 -7590 0 0 {name=p2041 lab=_2565_/Q }
C {devices/lab_pin.sym} 2670 -7610 0 1 {name=p2042 lab=_2557_/D }
C {sky130_stdcells/and2_4.sym} 2610 -7610 0 0 {name=X_1883_ }
C {devices/lab_pin.sym} 2550 -7490 0 0 {name=p2043 lab=_1952_/A }
C {devices/lab_pin.sym} 2550 -7450 0 0 {name=p2044 lab=_2521_/Q }
C {devices/lab_pin.sym} 2670 -7470 0 1 {name=p2045 lab=_1952_/X }
C {sky130_stdcells/and2_4.sym} 2610 -7470 0 0 {name=X_1952_ }
C {devices/lab_pin.sym} 2520 -7340 0 0 {name=p2046 lab=_2590_/CLK }
C {devices/lab_pin.sym} 2520 -7320 0 0 {name=p2047 lab=_2237_/Y }
C {devices/lab_pin.sym} 2700 -7340 0 1 {name=p2048 lab=_1218_/A }
C {sky130_stdcells/dfxtp_4.sym} 2610 -7330 0 0 {name=X_2435_ }
C {devices/lab_pin.sym} 2520 -7200 0 0 {name=p2049 lab=_2638_/CLK }
C {devices/lab_pin.sym} 2520 -7180 0 0 {name=p2050 lab=_1965_/Y }
C {devices/lab_pin.sym} 2700 -7200 0 1 {name=p2051 lab=_2504_/Q }
C {sky130_stdcells/dfxtp_4.sym} 2610 -7190 0 0 {name=X_2504_ }
C {devices/lab_pin.sym} 2520 -7060 0 0 {name=p2052 lab=_2367_/CLK }
C {devices/lab_pin.sym} 2520 -7040 0 0 {name=p2053 lab=_2365_/Q }
C {devices/lab_pin.sym} 2700 -7060 0 1 {name=p2054 lab=_1864_/A }
C {sky130_stdcells/dfxtp_4.sym} 2610 -7050 0 0 {name=X_2366_ }
C {devices/lab_pin.sym} 2530 -6940 0 0 {name=p2055 lab=_1318_/A }
C {devices/lab_pin.sym} 2530 -6900 0 0 {name=p2056 lab=_1316_/X }
C {devices/lab_pin.sym} 2530 -6860 0 0 {name=p2057 lab=_1306_/X }
C {devices/lab_pin.sym} 2690 -6900 0 1 {name=p2058 lab=_1319_/A }
C {sky130_stdcells/o21a_4.sym} 2610 -6900 0 0 {name=X_1317_ }
C {devices/lab_pin.sym} 2550 -6770 0 0 {name=p2059 lab=_1277_/A }
C {devices/lab_pin.sym} 2550 -6730 0 0 {name=p2060 lab=_2641_/Q }
C {devices/lab_pin.sym} 2670 -6750 0 1 {name=p2061 lab=_1249_/A }
C {sky130_stdcells/nand2_4.sym} 2610 -6750 0 0 {name=X_1248_ }
C {devices/lab_pin.sym} 2570 -6620 0 0 {name=p2062 lab=_2290_/Y }
C {devices/lab_pin.sym} 2650 -6620 0 1 {name=p2063 lab=_2304_/A }
C {sky130_stdcells/buf_2.sym} 2610 -6620 0 0 {name=X_2297_ }
C {sky130_stdcells/decap_3.sym} 2610 -6470 0 0 {name=XPHY_129 }
C {sky130_stdcells/decap_3.sym} 2610 -6290 0 0 {name=XPHY_118 }
C {sky130_stdcells/decap_3.sym} 2610 -6110 0 0 {name=XPHY_107 }
C {devices/lab_pin.sym} 2570 -5960 0 0 {name=p2064 lab=_1179_/A }
C {devices/lab_pin.sym} 2650 -5960 0 1 {name=p2065 lab=_1179_/X }
C {sky130_stdcells/buf_2.sym} 2610 -5960 0 0 {name=X_1179_ }
C {sky130_stdcells/decap_3.sym} 2610 -5810 0 0 {name=XPHY_9 }
C {devices/lab_pin.sym} 2550 -5680 0 0 {name=p2066 lab=_2081_/X }
C {devices/lab_pin.sym} 2550 -5640 0 0 {name=p2067 lab=_2044_/B }
C {devices/lab_pin.sym} 2550 -5600 0 0 {name=p2068 lab=_2060_/B }
C {devices/lab_pin.sym} 2670 -5640 0 1 {name=p2069 lab=_2474_/D }
C {sky130_stdcells/and3_4.sym} 2610 -5640 0 0 {name=X_2082_ }
C {devices/lab_pin.sym} 2530 -5520 0 0 {name=p2070 lab=_1625_/X }
C {devices/lab_pin.sym} 2530 -5480 0 0 {name=p2071 lab=_1913_/A }
C {devices/lab_pin.sym} 2530 -5440 0 0 {name=p2072 lab=_2448_/Q }
C {devices/lab_pin.sym} 2690 -5480 0 1 {name=p2073 lab=_2220_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -5480 0 0 {name=X_2220_ }
C {devices/lab_pin.sym} 2550 -5350 0 0 {name=p2074 lab=_2151_/A }
C {devices/lab_pin.sym} 2550 -5310 0 0 {name=p2075 lab=_2151_/B }
C {devices/lab_pin.sym} 2670 -5330 0 1 {name=p2076 lab=_2151_/Y }
C {sky130_stdcells/nand2_4.sym} 2610 -5330 0 0 {name=X_2151_ }
C {devices/lab_pin.sym} 2550 -5210 0 0 {name=p2077 lab=_1979_/A }
C {devices/lab_pin.sym} 2550 -5170 0 0 {name=p2078 lab=_2496_/Q }
C {devices/lab_pin.sym} 2670 -5190 0 1 {name=p2079 lab=_1980_/B }
C {sky130_stdcells/nand2_4.sym} 2610 -5190 0 0 {name=X_1866_ }
C {devices/lab_pin.sym} 2530 -5080 0 0 {name=p2080 lab=_1788_/X }
C {devices/lab_pin.sym} 2530 -5040 0 0 {name=p2081 lab=_1490_/A }
C {devices/lab_pin.sym} 2530 -5000 0 0 {name=p2082 lab=_2326_/A }
C {devices/lab_pin.sym} 2690 -5040 0 1 {name=p2083 lab=_1797_/X }
C {sky130_stdcells/o21a_4.sym} 2610 -5040 0 0 {name=X_1797_ }
C {devices/lab_pin.sym} 2570 -4900 0 0 {name=p2084 lab=_1339_/X }
C {devices/lab_pin.sym} 2650 -4900 0 1 {name=p2085 lab=_1938_/A }
C {sky130_stdcells/buf_2.sym} 2610 -4900 0 0 {name=X_1935_ }
C {devices/lab_pin.sym} 2520 -4780 0 0 {name=p2086 lab=_2445_/CLK }
C {devices/lab_pin.sym} 2520 -4760 0 0 {name=p2087 lab=_2281_/Y }
C {devices/lab_pin.sym} 2700 -4780 0 1 {name=p2088 lab=_1619_/A }
C {sky130_stdcells/dfxtp_4.sym} 2610 -4770 0 0 {name=X_2418_ }
C {devices/lab_pin.sym} 2550 -4650 0 0 {name=p2089 lab=_2349_/A }
C {devices/lab_pin.sym} 2550 -4610 0 0 {name=p2090 lab=MISO_fromClient }
C {devices/lab_pin.sym} 2670 -4630 0 1 {name=p2091 lab=_2349_/Y }
C {sky130_stdcells/nor2_4.sym} 2610 -4630 0 0 {name=X_2349_ }
C {devices/lab_pin.sym} 2570 -4500 0 0 {name=p2092 lab=clkbuf_4_3_0_m1_clk_local/A }
C {devices/lab_pin.sym} 2650 -4500 0 1 {name=p2093 lab=_2641_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 2610 -4500 0 0 {name=Xclkbuf_4_3_0_m1_clk_local }
C {devices/lab_pin.sym} 2570 -4380 0 0 {name=p2094 lab=_1651_/A }
C {devices/lab_pin.sym} 2650 -4380 0 1 {name=p2095 lab=_1651_/X }
C {sky130_stdcells/buf_2.sym} 2610 -4380 0 0 {name=X_1651_ }
C {devices/lab_pin.sym} 2530 -4280 0 0 {name=p2096 lab=_1718_/Y }
C {devices/lab_pin.sym} 2530 -4240 0 0 {name=p2097 lab=_1719_/X }
C {devices/lab_pin.sym} 2530 -4200 0 0 {name=p2098 lab=_1645_/A }
C {devices/lab_pin.sym} 2690 -4240 0 1 {name=p2099 lab=_1720_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -4240 0 0 {name=X_1720_ }
C {devices/lab_pin.sym} 2530 -4120 0 0 {name=p2100 lab=_1581_/X }
C {devices/lab_pin.sym} 2530 -4080 0 0 {name=p2101 lab=_1562_/Y }
C {devices/lab_pin.sym} 2530 -4040 0 0 {name=p2102 lab=_1569_/X }
C {devices/lab_pin.sym} 2690 -4080 0 1 {name=p2103 lab=_1582_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -4080 0 0 {name=X_1582_ }
C {devices/lab_pin.sym} 2530 -3960 0 0 {name=p2104 lab=_2055_/X }
C {devices/lab_pin.sym} 2530 -3920 0 0 {name=p2105 lab=_1993_/B }
C {devices/lab_pin.sym} 2530 -3880 0 0 {name=p2106 lab=_2064_/Y }
C {devices/lab_pin.sym} 2690 -3920 0 1 {name=p2107 lab=_2065_/X }
C {sky130_stdcells/o21a_4.sym} 2610 -3920 0 0 {name=X_2065_ }
C {devices/lab_pin.sym} 2550 -3800 0 0 {name=p2108 lab=_2123_/A }
C {devices/lab_pin.sym} 2550 -3760 0 0 {name=p2109 lab=_2335_/A }
C {devices/lab_pin.sym} 2550 -3720 0 0 {name=p2110 lab=_2134_/C }
C {devices/lab_pin.sym} 2670 -3760 0 1 {name=p2111 lab=_2134_/Y }
C {sky130_stdcells/nand3_4.sym} 2610 -3760 0 0 {name=X_2134_ }
C {devices/lab_pin.sym} 2550 -3630 0 0 {name=p2112 lab=_2181_/A }
C {devices/lab_pin.sym} 2550 -3590 0 0 {name=p2113 lab=_1764_/Y }
C {devices/lab_pin.sym} 2670 -3610 0 1 {name=p2114 lab=_2203_/Y }
C {sky130_stdcells/nor2_4.sym} 2610 -3610 0 0 {name=X_2203_ }
C {devices/lab_pin.sym} 2530 -3500 0 0 {name=p2115 lab=_1847_/Y }
C {devices/lab_pin.sym} 2530 -3460 0 0 {name=p2116 lab=_1624_/X }
C {devices/lab_pin.sym} 2530 -3420 0 0 {name=p2117 lab=_1848_/Y }
C {devices/lab_pin.sym} 2690 -3460 0 1 {name=p2118 lab=_1849_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -3460 0 0 {name=X_1849_ }
C {devices/lab_pin.sym} 2550 -3330 0 0 {name=p2119 lab=_1918_/A }
C {devices/lab_pin.sym} 2550 -3290 0 0 {name=p2120 lab=_2540_/Q }
C {devices/lab_pin.sym} 2670 -3310 0 1 {name=p2121 lab=_1918_/X }
C {sky130_stdcells/and2_4.sym} 2610 -3310 0 0 {name=X_1918_ }
C {devices/lab_pin.sym} 2570 -3180 0 0 {name=p2122 lab=_2447_/Q }
C {devices/lab_pin.sym} 2650 -3180 0 1 {name=p2123 lab=_1703_/A }
C {sky130_stdcells/buf_2.sym} 2610 -3180 0 0 {name=X_1634_ }
C {devices/lab_pin.sym} 2570 -3060 0 0 {name=p2124 lab=_1703_/A }
C {devices/lab_pin.sym} 2650 -3060 0 1 {name=p2125 lab=_1703_/X }
C {sky130_stdcells/buf_2.sym} 2610 -3060 0 0 {name=X_1703_ }
C {devices/lab_pin.sym} 2570 -2940 0 0 {name=p2126 lab=_2386_/Q }
C {devices/lab_pin.sym} 2650 -2940 0 1 {name=p2127 lab=_1731_/B }
C {sky130_stdcells/buf_2.sym} 2610 -2940 0 0 {name=X_1565_ }
C {devices/lab_pin.sym} 2530 -2840 0 0 {name=p2128 lab=_1487_/A }
C {devices/lab_pin.sym} 2530 -2800 0 0 {name=p2129 lab=_1494_/X }
C {devices/lab_pin.sym} 2530 -2760 0 0 {name=p2130 lab=_1495_/Y }
C {devices/lab_pin.sym} 2690 -2800 0 1 {name=p2131 lab=_1496_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -2800 0 0 {name=X_1496_ }
C {devices/lab_pin.sym} 2530 -2680 0 0 {name=p2132 lab=_2014_/X }
C {devices/lab_pin.sym} 2530 -2640 0 0 {name=p2133 lab=_2040_/X }
C {devices/lab_pin.sym} 2530 -2600 0 0 {name=p2134 lab=_1986_/Y }
C {devices/lab_pin.sym} 2690 -2640 0 1 {name=p2135 lab=_2048_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -2640 0 0 {name=X_2048_ }
C {devices/lab_pin.sym} 2570 -2500 0 0 {name=p2136 lab=_1602_/Y }
C {devices/lab_pin.sym} 2650 -2500 0 1 {name=p2137 lab=_2117_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -2500 0 0 {name=X_2117_ }
C {devices/lab_pin.sym} 2570 -2380 0 0 {name=p2138 lab=_1238_/Y }
C {devices/lab_pin.sym} 2650 -2380 0 1 {name=p2139 lab=_1350_/X }
C {sky130_stdcells/buf_2.sym} 2610 -2380 0 0 {name=X_1350_ }
C {devices/lab_pin.sym} 2530 -2300 0 0 {name=p2140 lab=_1256_/Y }
C {devices/lab_pin.sym} 2530 -2260 0 0 {name=p2141 lab=_1225_/X }
C {devices/lab_pin.sym} 2530 -2220 0 0 {name=p2142 lab=_1257_/X }
C {devices/lab_pin.sym} 2530 -2180 0 0 {name=p2143 lab=_1260_/Y }
C {devices/lab_pin.sym} 2530 -2140 0 0 {name=p2144 lab=_1280_/Y }
C {devices/lab_pin.sym} 2690 -2220 0 1 {name=p2145 lab=_1281_/Y }
C {sky130_stdcells/o41ai_4.sym} 2610 -2220 0 0 {name=X_1281_ }
C {devices/lab_pin.sym} 2520 -2060 0 0 {name=p2146 lab=_2598_/CLK }
C {devices/lab_pin.sym} 2520 -2040 0 0 {name=p2147 lab=_1603_/Y }
C {devices/lab_pin.sym} 2700 -2060 0 1 {name=p2148 lab=_1427_/A }
C {sky130_stdcells/dfxtp_4.sym} 2610 -2050 0 0 {name=X_2597_ }
C {devices/lab_pin.sym} 2570 -1920 0 0 {name=p2149 lab=_2448_/Q }
C {devices/lab_pin.sym} 2650 -1920 0 1 {name=p2150 lab=_1617_/Y }
C {sky130_stdcells/inv_2.sym} 2610 -1920 0 0 {name=X_1617_ }
C {devices/lab_pin.sym} 2550 -1830 0 0 {name=p2151 lab=_2602_/Q }
C {devices/lab_pin.sym} 2550 -1790 0 0 {name=p2152 lab=_1537_/X }
C {devices/lab_pin.sym} 2550 -1750 0 0 {name=p2153 lab=_1451_/X }
C {devices/lab_pin.sym} 2550 -1710 0 0 {name=p2154 lab=_1548_/D }
C {devices/lab_pin.sym} 2670 -1770 0 1 {name=p2155 lab=_1548_/Y }
C {sky130_stdcells/nor4_4.sym} 2610 -1770 0 0 {name=X_1548_ }
C {devices/lab_pin.sym} 2530 -1640 0 0 {name=p2156 lab=_1456_/X }
C {devices/lab_pin.sym} 2530 -1600 0 0 {name=p2157 lab=_1449_/B }
C {devices/lab_pin.sym} 2530 -1560 0 0 {name=p2158 lab=_1213_/X }
C {devices/lab_pin.sym} 2690 -1600 0 1 {name=p2159 lab=_1479_/Y }
C {sky130_stdcells/o21ai_4.sym} 2610 -1600 0 0 {name=X_1479_ }
C {devices/lab_pin.sym} 2530 -1480 0 0 {name=p2160 lab=_1408_/B }
C {devices/lab_pin.sym} 2530 -1440 0 0 {name=p2161 lab=_1231_/B }
C {devices/lab_pin.sym} 2530 -1400 0 0 {name=p2162 lab=_1283_/X }
C {devices/lab_pin.sym} 2690 -1440 0 1 {name=p2163 lab=_1402_/Y }
C {sky130_stdcells/a21oi_4.sym} 2610 -1440 0 0 {name=X_1402_ }
C {devices/lab_pin.sym} 2520 -1300 0 0 {name=p2164 lab=_2390_/CLK }
C {devices/lab_pin.sym} 2520 -1280 0 0 {name=p2165 lab=_2113_/X }
C {devices/lab_pin.sym} 2700 -1300 0 1 {name=p2166 lab=_1779_/C }
C {sky130_stdcells/dfxtp_4.sym} 2610 -1290 0 0 {name=X_2451_ }
C {devices/lab_pin.sym} 2520 -1160 0 0 {name=p2167 lab=_2528_/CLK }
C {devices/lab_pin.sym} 2520 -1140 0 0 {name=p2168 lab=_2520_/D }
C {devices/lab_pin.sym} 2700 -1160 0 1 {name=p2169 lab=_1953_/B }
C {sky130_stdcells/dfxtp_4.sym} 2610 -1150 0 0 {name=X_2520_ }
C {devices/lab_pin.sym} 2520 -1020 0 0 {name=p2170 lab=_2372_/CLK }
C {devices/lab_pin.sym} 2520 -1000 0 0 {name=p2171 lab=_2341_/Y }
C {devices/lab_pin.sym} 2700 -1020 0 1 {name=p2172 lab=_2363_/D }
C {sky130_stdcells/dfxtp_4.sym} 2610 -1010 0 0 {name=X_2382_ }
C {devices/lab_pin.sym} 2550 -910 0 0 {name=p2173 lab=_1333_/A }
C {devices/lab_pin.sym} 2550 -870 0 0 {name=p2174 lab=_1228_/Y }
C {devices/lab_pin.sym} 2550 -830 0 0 {name=p2175 lab=_1240_/Y }
C {devices/lab_pin.sym} 2550 -790 0 0 {name=p2176 lab=_1238_/Y }
C {devices/lab_pin.sym} 2670 -850 0 1 {name=p2177 lab=_1333_/Y }
C {sky130_stdcells/nor4_4.sym} 2610 -850 0 0 {name=X_1333_ }
C {devices/lab_pin.sym} 8150 -21920 0 0 {name=p2178 lab=_1263_/Y }
C {devices/lab_pin.sym} 8230 -21920 0 1 {name=p2179 lab=_1264_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -21920 0 0 {name=X_1264_ }
C {devices/lab_pin.sym} 8110 -21820 0 0 {name=p2180 lab=_1182_/A }
C {devices/lab_pin.sym} 8110 -21780 0 0 {name=p2181 lab=_1179_/X }
C {devices/lab_pin.sym} 8110 -21740 0 0 {name=p2182 lab=_1194_/X }
C {devices/lab_pin.sym} 8270 -21780 0 1 {name=p2183 lab=_1195_/Y }
C {sky130_stdcells/o21ai_4.sym} 8190 -21780 0 0 {name=X_1195_ }
C {devices/lab_pin.sym} 8100 -21640 0 0 {name=p2184 lab=_2457_/CLK }
C {devices/lab_pin.sym} 8100 -21620 0 0 {name=p2185 lab=_1201_/Y }
C {devices/lab_pin.sym} 8280 -21640 0 1 {name=p2186 lab=_1194_/A }
C {sky130_stdcells/dfxtp_4.sym} 8190 -21630 0 0 {name=X_2649_ }
C {devices/lab_pin.sym} 8130 -21510 0 0 {name=p2187 lab=_1885_/A }
C {devices/lab_pin.sym} 8130 -21470 0 0 {name=p2188 lab=_2566_/Q }
C {devices/lab_pin.sym} 8250 -21490 0 1 {name=p2189 lab=_2558_/D }
C {sky130_stdcells/and2_4.sym} 8190 -21490 0 0 {name=X_1882_ }
C {devices/lab_pin.sym} 8130 -21370 0 0 {name=p2190 lab=_1952_/A }
C {devices/lab_pin.sym} 8130 -21330 0 0 {name=p2191 lab=_1951_/B }
C {devices/lab_pin.sym} 8250 -21350 0 1 {name=p2192 lab=_1951_/X }
C {sky130_stdcells/and2_4.sym} 8190 -21350 0 0 {name=X_1951_ }
C {devices/lab_pin.sym} 8100 -21220 0 0 {name=p2193 lab=_2372_/CLK }
C {devices/lab_pin.sym} 8100 -21200 0 0 {name=p2194 lab=_2365_/D }
C {devices/lab_pin.sym} 8280 -21220 0 1 {name=p2195 lab=_2365_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -21210 0 0 {name=X_2365_ }
C {devices/lab_pin.sym} 8100 -21080 0 0 {name=p2196 lab=_2641_/CLK }
C {devices/lab_pin.sym} 8100 -21060 0 0 {name=p2197 lab=_2503_/D }
C {devices/lab_pin.sym} 8280 -21080 0 1 {name=p2198 lab=_2503_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -21070 0 0 {name=X_2503_ }
C {devices/lab_pin.sym} 8100 -20940 0 0 {name=p2199 lab=_2557_/CLK }
C {devices/lab_pin.sym} 8100 -20920 0 0 {name=p2200 lab=_2434_/D }
C {devices/lab_pin.sym} 8280 -20940 0 1 {name=p2201 lab=_2434_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -20930 0 0 {name=X_2434_ }
C {devices/lab_pin.sym} 8150 -20800 0 0 {name=p2202 lab=_1178_/A }
C {devices/lab_pin.sym} 8230 -20800 0 1 {name=p2203 lab=_1179_/A }
C {sky130_stdcells/buf_2.sym} 8190 -20800 0 0 {name=X_1178_ }
C {devices/lab_pin.sym} 8130 -20710 0 0 {name=p2204 lab=_1239_/Y }
C {devices/lab_pin.sym} 8130 -20670 0 0 {name=p2205 lab=_1316_/B }
C {devices/lab_pin.sym} 8130 -20630 0 0 {name=p2206 lab=_1241_/Y }
C {devices/lab_pin.sym} 8130 -20590 0 0 {name=p2207 lab=_1316_/D }
C {devices/lab_pin.sym} 8250 -20650 0 1 {name=p2208 lab=_1316_/X }
C {sky130_stdcells/and4_4.sym} 8190 -20650 0 0 {name=X_1316_ }
C {devices/lab_pin.sym} 8130 -20530 0 0 {name=p2209 lab=_1225_/X }
C {devices/lab_pin.sym} 8130 -20490 0 0 {name=p2210 lab=_1226_/Y }
C {devices/lab_pin.sym} 8130 -20450 0 0 {name=p2211 lab=_1257_/A }
C {devices/lab_pin.sym} 8130 -20410 0 0 {name=p2212 lab=_1246_/Y }
C {devices/lab_pin.sym} 8250 -20470 0 1 {name=p2213 lab=_1277_/B }
C {sky130_stdcells/nor4_4.sym} 8190 -20470 0 0 {name=X_1247_ }
C {devices/lab_pin.sym} 8110 -20340 0 0 {name=p2214 lab=_2266_/Y }
C {devices/lab_pin.sym} 8110 -20300 0 0 {name=p2215 lab=_2291_/X }
C {devices/lab_pin.sym} 8110 -20260 0 0 {name=p2216 lab=_2295_/Y }
C {devices/lab_pin.sym} 8270 -20300 0 1 {name=p2217 lab=_2296_/Y }
C {sky130_stdcells/o21ai_4.sym} 8190 -20300 0 0 {name=X_2296_ }
C {sky130_stdcells/decap_3.sym} 8190 -20130 0 0 {name=XPHY_119 }
C {sky130_stdcells/decap_3.sym} 8190 -19950 0 0 {name=XPHY_108 }
C {devices/lab_pin.sym} 8150 -19800 0 0 {name=p2218 lab=clkbuf_3_5_0_m1_clk_local/X }
C {devices/lab_pin.sym} 8230 -19800 0 1 {name=p2219 lab=_2506_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 8190 -19800 0 0 {name=Xclkbuf_4_11_0_m1_clk_local }
C {devices/lab_pin.sym} 8130 -19690 0 0 {name=p2220 lab=_1991_/D }
C {devices/lab_pin.sym} 8130 -19650 0 0 {name=p2221 lab=_2080_/Y }
C {devices/lab_pin.sym} 8250 -19670 0 1 {name=p2222 lab=_2081_/X }
C {sky130_stdcells/or2_4.sym} 8190 -19670 0 0 {name=X_2081_ }
C {devices/lab_pin.sym} 8150 -19540 0 0 {name=p2223 lab=_1623_/Y }
C {devices/lab_pin.sym} 8230 -19540 0 1 {name=p2224 lab=_2151_/A }
C {sky130_stdcells/buf_2.sym} 8190 -19540 0 0 {name=X_2150_ }
C {devices/lab_pin.sym} 8130 -19430 0 0 {name=p2225 lab=_1932_/A }
C {devices/lab_pin.sym} 8130 -19390 0 0 {name=p2226 lab=_2527_/Q }
C {devices/lab_pin.sym} 8250 -19410 0 1 {name=p2227 lab=_2523_/D }
C {sky130_stdcells/and2_4.sym} 8190 -19410 0 0 {name=X_1934_ }
C {devices/lab_pin.sym} 8130 -19300 0 0 {name=p2228 lab=_2365_/Q }
C {devices/lab_pin.sym} 8130 -19260 0 0 {name=p2229 lab=_2365_/D }
C {devices/lab_pin.sym} 8130 -19220 0 0 {name=p2230 lab=_1865_/C }
C {devices/lab_pin.sym} 8250 -19260 0 1 {name=p2231 lab=_1976_/A }
C {sky130_stdcells/nor3_4.sym} 8190 -19260 0 0 {name=X_1865_ }
C {devices/lab_pin.sym} 8110 -19140 0 0 {name=p2232 lab=_1983_/B }
C {devices/lab_pin.sym} 8110 -19100 0 0 {name=p2233 lab=_2577_/Q }
C {devices/lab_pin.sym} 8110 -19060 0 0 {name=p2234 lab=_1795_/X }
C {devices/lab_pin.sym} 8270 -19100 0 1 {name=p2235 lab=_1796_/X }
C {sky130_stdcells/o21a_4.sym} 8190 -19100 0 0 {name=X_1796_ }
C {devices/lab_pin.sym} 8150 -18960 0 0 {name=p2236 lab=_2464_/Q }
C {devices/lab_pin.sym} 8230 -18960 0 1 {name=p2237 lab=_2348_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -18960 0 0 {name=X_2348_ }
C {devices/lab_pin.sym} 8100 -18840 0 0 {name=p2238 lab=_2428_/CLK }
C {devices/lab_pin.sym} 8100 -18820 0 0 {name=p2239 lab=_2417_/D }
C {devices/lab_pin.sym} 8280 -18840 0 1 {name=p2240 lab=_2417_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -18830 0 0 {name=X_2417_ }
C {devices/lab_pin.sym} 8110 -18740 0 0 {name=p2241 lab=_1583_/X }
C {devices/lab_pin.sym} 8110 -18700 0 0 {name=p2242 lab=_1600_/B }
C {devices/lab_pin.sym} 8110 -18660 0 0 {name=p2243 lab=_1428_/C }
C {devices/lab_pin.sym} 8110 -18620 0 0 {name=p2244 lab=_1694_/X }
C {devices/lab_pin.sym} 8110 -18590 0 0 {name=p2245 lab=_1219_/X }
C {devices/lab_pin.sym} 8270 -18660 0 1 {name=p2246 lab=_2279_/X }
C {sky130_stdcells/a41o_4.sym} 8190 -18660 0 0 {name=X_2279_ }
C {devices/lab_pin.sym} 8150 -18500 0 0 {name=p2247 lab=_1649_/Y }
C {devices/lab_pin.sym} 8230 -18500 0 1 {name=p2248 lab=_1856_/A }
C {sky130_stdcells/buf_2.sym} 8190 -18500 0 0 {name=X_1650_ }
C {devices/lab_pin.sym} 8150 -18380 0 0 {name=p2249 lab=_2245_/B }
C {devices/lab_pin.sym} 8230 -18380 0 1 {name=p2250 lab=_1581_/X }
C {sky130_stdcells/buf_2.sym} 8190 -18380 0 0 {name=X_1581_ }
C {devices/lab_pin.sym} 8110 -18280 0 0 {name=p2251 lab=_2198_/Y }
C {devices/lab_pin.sym} 8110 -18240 0 0 {name=p2252 lab=_2201_/Y }
C {devices/lab_pin.sym} 8110 -18200 0 0 {name=p2253 lab=_2449_/Q }
C {devices/lab_pin.sym} 8270 -18240 0 1 {name=p2254 lab=_2202_/X }
C {sky130_stdcells/a21o_4.sym} 8190 -18240 0 0 {name=X_2202_ }
C {devices/lab_pin.sym} 8110 -18140 0 0 {name=p2255 lab=_2058_/X }
C {devices/lab_pin.sym} 8110 -18100 0 0 {name=p2256 lab=_2060_/Y }
C {devices/lab_pin.sym} 8110 -18060 0 0 {name=p2257 lab=_2062_/B }
C {devices/lab_pin.sym} 8110 -18020 0 0 {name=p2258 lab=_2055_/X }
C {devices/lab_pin.sym} 8110 -17990 0 0 {name=p2259 lab=_1275_/X }
C {devices/lab_pin.sym} 8270 -18060 0 1 {name=p2260 lab=_2064_/Y }
C {sky130_stdcells/a41oi_4.sym} 8190 -18060 0 0 {name=X_2064_ }
C {devices/lab_pin.sym} 8130 -17920 0 0 {name=p2261 lab=_1874_/A }
C {devices/lab_pin.sym} 8130 -17880 0 0 {name=p2262 lab=_2121_/X }
C {devices/lab_pin.sym} 8130 -17840 0 0 {name=p2263 lab=_1490_/A }
C {devices/lab_pin.sym} 8250 -17880 0 1 {name=p2264 lab=_2133_/Y }
C {sky130_stdcells/nand3_4.sym} 8190 -17880 0 0 {name=X_2133_ }
C {devices/lab_pin.sym} 8130 -17750 0 0 {name=p2265 lab=_1918_/A }
C {devices/lab_pin.sym} 8130 -17710 0 0 {name=p2266 lab=_2541_/Q }
C {devices/lab_pin.sym} 8250 -17730 0 1 {name=p2267 lab=_1917_/X }
C {sky130_stdcells/and2_4.sym} 8190 -17730 0 0 {name=X_1917_ }
C {devices/lab_pin.sym} 8130 -17620 0 0 {name=p2268 lab=_1778_/X }
C {devices/lab_pin.sym} 8130 -17580 0 0 {name=p2269 lab=_1678_/A }
C {devices/lab_pin.sym} 8130 -17540 0 0 {name=p2270 lab=_1779_/C }
C {devices/lab_pin.sym} 8250 -17580 0 1 {name=p2271 lab=_1779_/Y }
C {sky130_stdcells/nand3_4.sym} 8190 -17580 0 0 {name=X_1779_ }
C {devices/lab_pin.sym} 8110 -17460 0 0 {name=p2272 lab=_1625_/X }
C {devices/lab_pin.sym} 8110 -17420 0 0 {name=p2273 lab=_1902_/A }
C {devices/lab_pin.sym} 8110 -17380 0 0 {name=p2274 lab=_2448_/Q }
C {devices/lab_pin.sym} 8270 -17420 0 1 {name=p2275 lab=_1848_/Y }
C {sky130_stdcells/a21oi_4.sym} 8190 -17420 0 0 {name=X_1848_ }
C {devices/lab_pin.sym} 8150 -17280 0 0 {name=p2276 lab=clkbuf_4_1_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 8230 -17280 0 1 {name=p2277 lab=_2408_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 8190 -17280 0 0 {name=Xclkbuf_4_1_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 8130 -17170 0 0 {name=p2278 lab=_1530_/Y }
C {devices/lab_pin.sym} 8130 -17130 0 0 {name=p2279 lab=_1563_/Y }
C {devices/lab_pin.sym} 8250 -17150 0 1 {name=p2280 lab=_1564_/X }
C {sky130_stdcells/or2_4.sym} 8190 -17150 0 0 {name=X_1564_ }
C {devices/lab_pin.sym} 8150 -17020 0 0 {name=p2281 lab=_1701_/Y }
C {devices/lab_pin.sym} 8230 -17020 0 1 {name=p2282 lab=_1702_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -17020 0 0 {name=X_1702_ }
C {devices/lab_pin.sym} 8150 -16900 0 0 {name=p2283 lab=_1632_/Y }
C {devices/lab_pin.sym} 8230 -16900 0 1 {name=p2284 lab=_1633_/X }
C {sky130_stdcells/buf_2.sym} 8190 -16900 0 0 {name=X_1633_ }
C {devices/lab_pin.sym} 8110 -16820 0 0 {name=p2285 lab=_1487_/A }
C {devices/lab_pin.sym} 8110 -16780 0 0 {name=p2286 lab=_1505_/B }
C {devices/lab_pin.sym} 8110 -16740 0 0 {name=p2287 lab=_1494_/B }
C {devices/lab_pin.sym} 8110 -16700 0 0 {name=p2288 lab=_1505_/C }
C {devices/lab_pin.sym} 8110 -16670 0 0 {name=p2289 lab=_2340_/C }
C {devices/lab_pin.sym} 8270 -16740 0 1 {name=p2290 lab=_1495_/Y }
C {sky130_stdcells/a41oi_4.sym} 8190 -16740 0 0 {name=X_1495_ }
C {devices/lab_pin.sym} 8150 -16580 0 0 {name=p2291 lab=_2047_/A }
C {devices/lab_pin.sym} 8230 -16580 0 1 {name=p2292 lab=_2049_/A }
C {sky130_stdcells/inv_2.sym} 8190 -16580 0 0 {name=X_2047_ }
C {devices/lab_pin.sym} 8110 -16500 0 0 {name=p2293 lab=_1545_/X }
C {devices/lab_pin.sym} 8110 -16460 0 0 {name=p2294 lab=_1576_/X }
C {devices/lab_pin.sym} 8110 -16420 0 0 {name=p2295 lab=_1588_/Y }
C {devices/lab_pin.sym} 8110 -16380 0 0 {name=p2296 lab=_1593_/Y }
C {devices/lab_pin.sym} 8110 -16350 0 0 {name=p2297 lab=_1595_/X }
C {devices/lab_pin.sym} 8270 -16420 0 1 {name=p2298 lab=_2448_/D }
C {sky130_stdcells/a41oi_4.sym} 8190 -16420 0 0 {name=X_2116_ }
C {devices/lab_pin.sym} 8150 -16260 0 0 {name=p2299 lab=clkbuf_3_7_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 8230 -16260 0 1 {name=p2300 lab=clkbuf_3_6_0_addressalyzerBlock.SPI_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 8190 -16260 0 0 {name=Xclkbuf_3_6_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 8150 -16140 0 0 {name=p2301 lab=_2641_/Q }
C {devices/lab_pin.sym} 8230 -16140 0 1 {name=p2302 lab=_1280_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -16140 0 0 {name=X_1280_ }
C {devices/lab_pin.sym} 8100 -16020 0 0 {name=p2303 lab=_2590_/CLK }
C {devices/lab_pin.sym} 8100 -16000 0 0 {name=p2304 lab=_2596_/D }
C {devices/lab_pin.sym} 8280 -16020 0 1 {name=p2305 lab=_1676_/B }
C {sky130_stdcells/dfxtp_4.sym} 8190 -16010 0 0 {name=X_2596_ }
C {devices/lab_pin.sym} 8110 -15900 0 0 {name=p2306 lab=_1443_/A }
C {devices/lab_pin.sym} 8110 -15860 0 0 {name=p2307 lab=_2390_/Q }
C {devices/lab_pin.sym} 8110 -15820 0 0 {name=p2308 lab=_1477_/A }
C {devices/lab_pin.sym} 8270 -15860 0 1 {name=p2309 lab=_1547_/X }
C {sky130_stdcells/o21a_4.sym} 8190 -15860 0 0 {name=X_1547_ }
C {devices/lab_pin.sym} 8150 -15720 0 0 {name=p2310 lab=_2447_/Q }
C {devices/lab_pin.sym} 8230 -15720 0 1 {name=p2311 lab=_2181_/A }
C {sky130_stdcells/buf_2.sym} 8190 -15720 0 0 {name=X_1616_ }
C {devices/lab_pin.sym} 8110 -15620 0 0 {name=p2312 lab=_2268_/A }
C {devices/lab_pin.sym} 8110 -15580 0 0 {name=p2313 lab=_2333_/B }
C {devices/lab_pin.sym} 8110 -15540 0 0 {name=p2314 lab=_1462_/X }
C {devices/lab_pin.sym} 8270 -15580 0 1 {name=p2315 lab=_1478_/Y }
C {sky130_stdcells/a21oi_4.sym} 8190 -15580 0 0 {name=X_1478_ }
C {devices/lab_pin.sym} 8100 -15440 0 0 {name=p2316 lab=_2498_/CLK }
C {devices/lab_pin.sym} 8100 -15420 0 0 {name=p2317 lab=_2381_/D }
C {devices/lab_pin.sym} 8280 -15440 0 1 {name=p2318 lab=_2383_/D }
C {sky130_stdcells/dfxtp_4.sym} 8190 -15430 0 0 {name=X_2381_ }
C {devices/lab_pin.sym} 8130 -15310 0 0 {name=p2319 lab=_1397_/B }
C {devices/lab_pin.sym} 8130 -15270 0 0 {name=p2320 lab=_1397_/C }
C {devices/lab_pin.sym} 8250 -15290 0 1 {name=p2321 lab=_1408_/B }
C {sky130_stdcells/nor2_4.sym} 8190 -15290 0 0 {name=X_1401_ }
C {devices/lab_pin.sym} 8100 -15160 0 0 {name=p2322 lab=_2390_/CLK }
C {devices/lab_pin.sym} 8100 -15140 0 0 {name=p2323 lab=_2114_/X }
C {devices/lab_pin.sym} 8280 -15160 0 1 {name=p2324 lab=_2113_/B }
C {sky130_stdcells/dfxtp_4.sym} 8190 -15150 0 0 {name=X_2450_ }
C {devices/lab_pin.sym} 8130 -15030 0 0 {name=p2325 lab=_1194_/A }
C {devices/lab_pin.sym} 8130 -14990 0 0 {name=p2326 lab=_1194_/B }
C {devices/lab_pin.sym} 8250 -15010 0 1 {name=p2327 lab=_1194_/X }
C {sky130_stdcells/or2_4.sym} 8190 -15010 0 0 {name=X_1194_ }
C {devices/lab_pin.sym} 8150 -14880 0 0 {name=p2328 lab=_2629_/Q }
C {devices/lab_pin.sym} 8230 -14880 0 1 {name=p2329 lab=_1333_/A }
C {sky130_stdcells/inv_2.sym} 8190 -14880 0 0 {name=X_1332_ }
C {devices/lab_pin.sym} 8130 -14780 0 0 {name=p2330 lab=_1263_/A }
C {devices/lab_pin.sym} 8130 -14740 0 0 {name=p2331 lab=_1971_/A }
C {devices/lab_pin.sym} 8130 -14700 0 0 {name=p2332 lab=_1263_/C }
C {devices/lab_pin.sym} 8250 -14740 0 1 {name=p2333 lab=_1263_/Y }
C {sky130_stdcells/nand3_4.sym} 8190 -14740 0 0 {name=X_1263_ }
C {devices/lab_pin.sym} 8100 -14600 0 0 {name=p2334 lab=_2457_/CLK }
C {devices/lab_pin.sym} 8100 -14580 0 0 {name=p2335 lab=_1205_/Y }
C {devices/lab_pin.sym} 8280 -14600 0 1 {name=p2336 lab=_2648_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -14590 0 0 {name=X_2648_ }
C {devices/lab_pin.sym} 8100 -14460 0 0 {name=p2337 lab=_2606_/CLK }
C {devices/lab_pin.sym} 8100 -14440 0 0 {name=p2338 lab=_2579_/D }
C {devices/lab_pin.sym} 8280 -14460 0 1 {name=p2339 lab=_2579_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -14450 0 0 {name=X_2579_ }
C {devices/lab_pin.sym} 8150 -14320 0 0 {name=p2340 lab=_1254_/X }
C {devices/lab_pin.sym} 8230 -14320 0 1 {name=p2341 lab=_1952_/A }
C {sky130_stdcells/buf_2.sym} 8190 -14320 0 0 {name=X_1950_ }
C {devices/lab_pin.sym} 8130 -14210 0 0 {name=p2342 lab=_1885_/A }
C {devices/lab_pin.sym} 8130 -14170 0 0 {name=p2343 lab=DATA_FROM_HASH[0] }
C {devices/lab_pin.sym} 8250 -14190 0 1 {name=p2344 lab=_2559_/D }
C {sky130_stdcells/and2_4.sym} 8190 -14190 0 0 {name=X_1881_ }
C {devices/lab_pin.sym} 8100 -14060 0 0 {name=p2345 lab=_2513_/CLK }
C {devices/lab_pin.sym} 8100 -14040 0 0 {name=p2346 lab=_2502_/D }
C {devices/lab_pin.sym} 8280 -14060 0 1 {name=p2347 lab=MACRO_WR_SELECT[3] }
C {sky130_stdcells/dfxtp_4.sym} 8190 -14050 0 0 {name=X_2502_ }
C {devices/lab_pin.sym} 8100 -13920 0 0 {name=p2348 lab=_2372_/CLK }
C {devices/lab_pin.sym} 8100 -13900 0 0 {name=p2349 lab=_2363_/Q }
C {devices/lab_pin.sym} 8280 -13920 0 1 {name=p2350 lab=_2365_/D }
C {sky130_stdcells/dfxtp_4.sym} 8190 -13910 0 0 {name=X_2364_ }
C {devices/lab_pin.sym} 8150 -13780 0 0 {name=p2351 lab=_1244_/B }
C {devices/lab_pin.sym} 8230 -13780 0 1 {name=p2352 lab=_1316_/B }
C {sky130_stdcells/buf_2.sym} 8190 -13780 0 0 {name=X_1315_ }
C {devices/lab_pin.sym} 8100 -13660 0 0 {name=p2353 lab=_2428_/CLK }
C {devices/lab_pin.sym} 8100 -13640 0 0 {name=p2354 lab=_2433_/D }
C {devices/lab_pin.sym} 8280 -13660 0 1 {name=p2355 lab=_1709_/A }
C {sky130_stdcells/dfxtp_4.sym} 8190 -13650 0 0 {name=X_2433_ }
C {devices/lab_pin.sym} 8130 -13550 0 0 {name=p2356 lab=_1239_/Y }
C {devices/lab_pin.sym} 8130 -13510 0 0 {name=p2357 lab=_1241_/Y }
C {devices/lab_pin.sym} 8130 -13470 0 0 {name=p2358 lab=_1243_/X }
C {devices/lab_pin.sym} 8130 -13430 0 0 {name=p2359 lab=_1246_/D }
C {devices/lab_pin.sym} 8250 -13490 0 1 {name=p2360 lab=_1246_/Y }
C {sky130_stdcells/nand4_4.sym} 8190 -13490 0 0 {name=X_1246_ }
C {devices/lab_pin.sym} 8130 -13360 0 0 {name=p2361 lab=_2292_/X }
C {devices/lab_pin.sym} 8130 -13320 0 0 {name=p2362 lab=_2298_/B }
C {devices/lab_pin.sym} 8130 -13280 0 0 {name=p2363 lab=_2295_/C }
C {devices/lab_pin.sym} 8250 -13320 0 1 {name=p2364 lab=_2295_/Y }
C {sky130_stdcells/nand3_4.sym} 8190 -13320 0 0 {name=X_2295_ }
C {sky130_stdcells/decap_3.sym} 8190 -13150 0 0 {name=XPHY_109 }
C {devices/lab_pin.sym} 8150 -13000 0 0 {name=p2365 lab=_2084_/C }
C {devices/lab_pin.sym} 8230 -13000 0 1 {name=p2366 lab=_2080_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -13000 0 0 {name=X_2080_ }
C {devices/lab_pin.sym} 8130 -12890 0 0 {name=p2367 lab=_1932_/A }
C {devices/lab_pin.sym} 8130 -12850 0 0 {name=p2368 lab=_1933_/B }
C {devices/lab_pin.sym} 8250 -12870 0 1 {name=p2369 lab=_2524_/D }
C {sky130_stdcells/and2_4.sym} 8190 -12870 0 0 {name=X_1933_ }
C {devices/lab_pin.sym} 8150 -12740 0 0 {name=p2370 lab=_1864_/A }
C {devices/lab_pin.sym} 8230 -12740 0 1 {name=p2371 lab=_1865_/C }
C {sky130_stdcells/inv_2.sym} 8190 -12740 0 0 {name=X_1864_ }
C {devices/lab_pin.sym} 8110 -12640 0 0 {name=p2372 lab=_1788_/X }
C {devices/lab_pin.sym} 8110 -12600 0 0 {name=p2373 lab=_2268_/A }
C {devices/lab_pin.sym} 8110 -12560 0 0 {name=p2374 lab=_2326_/A }
C {devices/lab_pin.sym} 8270 -12600 0 1 {name=p2375 lab=_1795_/X }
C {sky130_stdcells/o21a_4.sym} 8190 -12600 0 0 {name=X_1795_ }
C {devices/lab_pin.sym} 8110 -12480 0 0 {name=p2376 lab=_2567_/Q }
C {devices/lab_pin.sym} 8110 -12440 0 0 {name=p2377 lab=S1_CLK_SELECT }
C {devices/lab_pin.sym} 8110 -12400 0 0 {name=p2378 lab=_2346_/Y }
C {devices/lab_pin.sym} 8270 -12440 0 1 {name=p2379 lab=_2347_/X }
C {sky130_stdcells/o21a_4.sym} 8190 -12440 0 0 {name=X_2347_ }
C {devices/lab_pin.sym} 8100 -12300 0 0 {name=p2380 lab=_2445_/CLK }
C {devices/lab_pin.sym} 8100 -12280 0 0 {name=p2381 lab=_2416_/D }
C {devices/lab_pin.sym} 8280 -12300 0 1 {name=p2382 lab=_1844_/A }
C {sky130_stdcells/dfxtp_4.sym} 8190 -12290 0 0 {name=X_2416_ }
C {devices/lab_pin.sym} 8150 -12160 0 0 {name=p2383 lab=_2278_/A }
C {devices/lab_pin.sym} 8230 -12160 0 1 {name=p2384 lab=_2278_/X }
C {sky130_stdcells/buf_2.sym} 8190 -12160 0 0 {name=X_2278_ }
C {devices/lab_pin.sym} 8150 -12040 0 0 {name=p2385 lab=_2619_/Q }
C {devices/lab_pin.sym} 8230 -12040 0 1 {name=p2386 lab=_1233_/A }
C {sky130_stdcells/inv_2.sym} 8190 -12040 0 0 {name=X_1229_ }
C {devices/lab_pin.sym} 8150 -11920 0 0 {name=p2387 lab=_1579_/X }
C {devices/lab_pin.sym} 8230 -11920 0 1 {name=p2388 lab=_2245_/B }
C {sky130_stdcells/buf_2.sym} 8190 -11920 0 0 {name=X_1580_ }
C {devices/lab_pin.sym} 8110 -11820 0 0 {name=p2389 lab=_2120_/X }
C {devices/lab_pin.sym} 8110 -11780 0 0 {name=p2390 lab=_2130_/Y }
C {devices/lab_pin.sym} 8110 -11740 0 0 {name=p2391 lab=_2131_/Y }
C {devices/lab_pin.sym} 8270 -11780 0 1 {name=p2392 lab=_2444_/D }
C {sky130_stdcells/o21ai_4.sym} 8190 -11780 0 0 {name=X_2132_ }
C {devices/lab_pin.sym} 8130 -11660 0 0 {name=p2393 lab=_2199_/Y }
C {devices/lab_pin.sym} 8130 -11620 0 0 {name=p2394 lab=_2179_/B }
C {devices/lab_pin.sym} 8130 -11580 0 0 {name=p2395 lab=_2201_/C }
C {devices/lab_pin.sym} 8250 -11620 0 1 {name=p2396 lab=_2201_/Y }
C {sky130_stdcells/nand3_4.sym} 8190 -11620 0 0 {name=X_2201_ }
C {devices/lab_pin.sym} 8130 -11500 0 0 {name=p2397 lab=_2063_/A }
C {devices/lab_pin.sym} 8130 -11460 0 0 {name=p2398 lab=_2061_/Y }
C {devices/lab_pin.sym} 8130 -11420 0 0 {name=p2399 lab=_2062_/X }
C {devices/lab_pin.sym} 8250 -11460 0 1 {name=p2400 lab=_2480_/D }
C {sky130_stdcells/nor3_4.sym} 8190 -11460 0 0 {name=X_2063_ }
C {devices/lab_pin.sym} 8150 -11320 0 0 {name=p2401 lab=_1847_/A }
C {devices/lab_pin.sym} 8230 -11320 0 1 {name=p2402 lab=_1847_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -11320 0 0 {name=X_1847_ }
C {devices/lab_pin.sym} 8130 -11210 0 0 {name=p2403 lab=_1918_/A }
C {devices/lab_pin.sym} 8130 -11170 0 0 {name=p2404 lab=_2542_/Q }
C {devices/lab_pin.sym} 8250 -11190 0 1 {name=p2405 lab=_1916_/X }
C {sky130_stdcells/and2_4.sym} 8190 -11190 0 0 {name=X_1916_ }
C {devices/lab_pin.sym} 8110 -11080 0 0 {name=p2406 lab=_1783_/B }
C {devices/lab_pin.sym} 8110 -11040 0 0 {name=p2407 lab=_1783_/D }
C {devices/lab_pin.sym} 8110 -11000 0 0 {name=p2408 lab=_1440_/D }
C {devices/lab_pin.sym} 8270 -11040 0 1 {name=p2409 lab=_1778_/X }
C {sky130_stdcells/a21o_4.sym} 8190 -11040 0 0 {name=X_1778_ }
C {devices/lab_pin.sym} 8130 -10910 0 0 {name=p2410 lab=_1701_/A }
C {devices/lab_pin.sym} 8130 -10870 0 0 {name=p2411 lab=_1701_/B }
C {devices/lab_pin.sym} 8250 -10890 0 1 {name=p2412 lab=_1701_/Y }
C {sky130_stdcells/nand2_4.sym} 8190 -10890 0 0 {name=X_1701_ }
C {devices/lab_pin.sym} 8110 -10800 0 0 {name=p2413 lab=_1435_/Y }
C {devices/lab_pin.sym} 8110 -10760 0 0 {name=p2414 lab=_1667_/A }
C {devices/lab_pin.sym} 8110 -10720 0 0 {name=p2415 lab=_1562_/Y }
C {devices/lab_pin.sym} 8110 -10680 0 0 {name=p2416 lab=_1497_/A }
C {devices/lab_pin.sym} 8110 -10640 0 0 {name=p2417 lab=_1527_/Y }
C {devices/lab_pin.sym} 8270 -10720 0 1 {name=p2418 lab=_1563_/Y }
C {sky130_stdcells/a32oi_4.sym} 8190 -10720 0 0 {name=X_1563_ }
C {devices/lab_pin.sym} 8130 -10590 0 0 {name=p2419 lab=_1433_/A }
C {devices/lab_pin.sym} 8130 -10550 0 0 {name=p2420 lab=_1494_/B }
C {devices/lab_pin.sym} 8130 -10510 0 0 {name=p2421 lab=_1505_/C }
C {devices/lab_pin.sym} 8130 -10470 0 0 {name=p2422 lab=_1438_/D }
C {devices/lab_pin.sym} 8250 -10530 0 1 {name=p2423 lab=_1494_/X }
C {sky130_stdcells/and4_4.sym} 8190 -10530 0 0 {name=X_1494_ }
C {devices/lab_pin.sym} 8150 -10380 0 0 {name=p2424 lab=_2449_/Q }
C {devices/lab_pin.sym} 8230 -10380 0 1 {name=p2425 lab=_1632_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -10380 0 0 {name=X_1632_ }
C {devices/lab_pin.sym} 8110 -10300 0 0 {name=p2426 lab=_1545_/X }
C {devices/lab_pin.sym} 8110 -10260 0 0 {name=p2427 lab=_1576_/X }
C {devices/lab_pin.sym} 8110 -10220 0 0 {name=p2428 lab=_1578_/Y }
C {devices/lab_pin.sym} 8110 -10180 0 0 {name=p2429 lab=_1582_/Y }
C {devices/lab_pin.sym} 8110 -10150 0 0 {name=p2430 lab=_1586_/X }
C {devices/lab_pin.sym} 8270 -10220 0 1 {name=p2431 lab=_2449_/D }
C {sky130_stdcells/a41oi_4.sym} 8190 -10220 0 0 {name=X_2115_ }
C {devices/lab_pin.sym} 8130 -10080 0 0 {name=p2432 lab=_1395_/A }
C {devices/lab_pin.sym} 8130 -10040 0 0 {name=p2433 lab=_1994_/Y }
C {devices/lab_pin.sym} 8130 -10000 0 0 {name=p2434 lab=_2046_/C }
C {devices/lab_pin.sym} 8250 -10040 0 1 {name=p2435 lab=_2046_/Y }
C {sky130_stdcells/nor3_4.sym} 8190 -10040 0 0 {name=X_2046_ }
C {devices/lab_pin.sym} 8150 -9900 0 0 {name=p2436 lab=clkbuf_3_4_0_m1_clk_local/A }
C {devices/lab_pin.sym} 8230 -9900 0 1 {name=p2437 lab=clkbuf_3_5_0_m1_clk_local/X }
C {sky130_stdcells/clkbuf_1.sym} 8190 -9900 0 0 {name=Xclkbuf_3_5_0_m1_clk_local }
C {devices/lab_pin.sym} 8100 -9780 0 0 {name=p2438 lab=_2390_/CLK }
C {devices/lab_pin.sym} 8100 -9760 0 0 {name=p2439 lab=_1686_/Y }
C {devices/lab_pin.sym} 8280 -9780 0 1 {name=p2440 lab=_1678_/A }
C {sky130_stdcells/dfxtp_4.sym} 8190 -9770 0 0 {name=X_2595_ }
C {devices/lab_pin.sym} 8110 -9680 0 0 {name=p2441 lab=_1544_/Y }
C {devices/lab_pin.sym} 8110 -9640 0 0 {name=p2442 lab=_1442_/X }
C {devices/lab_pin.sym} 8110 -9600 0 0 {name=p2443 lab=_1545_/X }
C {devices/lab_pin.sym} 8110 -9560 0 0 {name=p2444 lab=_1529_/Y }
C {devices/lab_pin.sym} 8110 -9530 0 0 {name=p2445 lab=_1467_/Y }
C {devices/lab_pin.sym} 8270 -9600 0 1 {name=p2446 lab=_1546_/X }
C {sky130_stdcells/a41o_4.sym} 8190 -9600 0 0 {name=X_1546_ }
C {devices/lab_pin.sym} 8110 -9460 0 0 {name=p2447 lab=_1534_/X }
C {devices/lab_pin.sym} 8110 -9420 0 0 {name=p2448 lab=_2558_/Q }
C {devices/lab_pin.sym} 8110 -9380 0 0 {name=p2449 lab=_1614_/X }
C {devices/lab_pin.sym} 8270 -9420 0 1 {name=p2450 lab=_1615_/Y }
C {sky130_stdcells/o21ai_4.sym} 8190 -9420 0 0 {name=X_1615_ }
C {devices/lab_pin.sym} 8150 -9280 0 0 {name=p2451 lab=_1477_/A }
C {devices/lab_pin.sym} 8230 -9280 0 1 {name=p2452 lab=_2268_/A }
C {sky130_stdcells/buf_2.sym} 8190 -9280 0 0 {name=X_1477_ }
C {devices/lab_pin.sym} 8130 -9170 0 0 {name=p2453 lab=_2014_/X }
C {devices/lab_pin.sym} 8130 -9130 0 0 {name=p2454 lab=_1994_/D }
C {devices/lab_pin.sym} 8250 -9150 0 1 {name=p2455 lab=_2029_/Y }
C {sky130_stdcells/nor2_4.sym} 8190 -9150 0 0 {name=X_2029_ }
C {devices/lab_pin.sym} 8100 -9020 0 0 {name=p2456 lab=_2498_/CLK }
C {devices/lab_pin.sym} 8100 -9000 0 0 {name=p2457 lab=_2379_/Q }
C {devices/lab_pin.sym} 8280 -9020 0 1 {name=p2458 lab=_2381_/D }
C {sky130_stdcells/dfxtp_4.sym} 8190 -9010 0 0 {name=X_2380_ }
C {devices/lab_pin.sym} 8150 -8880 0 0 {name=p2459 lab=_1400_/A }
C {devices/lab_pin.sym} 8230 -8880 0 1 {name=p2460 lab=_1400_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -8880 0 0 {name=X_1400_ }
C {devices/lab_pin.sym} 8110 -8780 0 0 {name=p2461 lab=_1335_/A }
C {devices/lab_pin.sym} 8110 -8740 0 0 {name=p2462 lab=_1330_/X }
C {devices/lab_pin.sym} 8110 -8700 0 0 {name=p2463 lab=_1306_/X }
C {devices/lab_pin.sym} 8270 -8740 0 1 {name=p2464 lab=_1331_/X }
C {sky130_stdcells/o21a_4.sym} 8190 -8740 0 0 {name=X_1331_ }
C {devices/lab_pin.sym} 8110 -8620 0 0 {name=p2465 lab=_1183_/Y }
C {devices/lab_pin.sym} 8110 -8580 0 0 {name=p2466 lab=_1187_/X }
C {devices/lab_pin.sym} 8110 -8540 0 0 {name=p2467 lab=_1192_/Y }
C {devices/lab_pin.sym} 8270 -8580 0 1 {name=p2468 lab=_1193_/Y }
C {sky130_stdcells/a21oi_4.sym} 8190 -8580 0 0 {name=X_1193_ }
C {devices/lab_pin.sym} 8130 -8470 0 0 {name=p2469 lab=_1251_/A }
C {devices/lab_pin.sym} 8130 -8430 0 0 {name=p2470 lab=_1261_/Y }
C {devices/lab_pin.sym} 8130 -8390 0 0 {name=p2471 lab=_1262_/C }
C {devices/lab_pin.sym} 8130 -8350 0 0 {name=p2472 lab=_1249_/Y }
C {devices/lab_pin.sym} 8250 -8410 0 1 {name=p2473 lab=_1263_/C }
C {sky130_stdcells/nand4_4.sym} 8190 -8410 0 0 {name=X_1262_ }
C {devices/lab_pin.sym} 8100 -8260 0 0 {name=p2474 lab=_2457_/CLK }
C {devices/lab_pin.sym} 8100 -8240 0 0 {name=p2475 lab=_2647_/D }
C {devices/lab_pin.sym} 8280 -8260 0 1 {name=p2476 lab=_2647_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -8250 0 0 {name=X_2647_ }
C {devices/lab_pin.sym} 8150 -8120 0 0 {name=p2477 lab=_1528_/Y }
C {devices/lab_pin.sym} 8230 -8120 0 1 {name=p2478 lab=_1529_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -8120 0 0 {name=X_1529_ }
C {devices/lab_pin.sym} 8100 -8000 0 0 {name=p2479 lab=_2606_/CLK }
C {devices/lab_pin.sym} 8100 -7980 0 0 {name=p2480 lab=_2578_/D }
C {devices/lab_pin.sym} 8280 -8000 0 1 {name=p2481 lab=_2578_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -7990 0 0 {name=X_2578_ }
C {sky130_stdcells/decap_3.sym} 8190 -7830 0 0 {name=XPHY_90 }
C {devices/lab_pin.sym} 8150 -7680 0 0 {name=p2482 lab=_1874_/A }
C {devices/lab_pin.sym} 8230 -7680 0 1 {name=p2483 lab=_1885_/A }
C {sky130_stdcells/buf_2.sym} 8190 -7680 0 0 {name=X_1880_ }
C {devices/lab_pin.sym} 8100 -7560 0 0 {name=p2484 lab=_2496_/CLK }
C {devices/lab_pin.sym} 8100 -7540 0 0 {name=p2485 lab=_1969_/X }
C {devices/lab_pin.sym} 8280 -7560 0 1 {name=p2486 lab=MACRO_WR_SELECT[2] }
C {sky130_stdcells/dfxtp_4.sym} 8190 -7550 0 0 {name=X_2501_ }
C {devices/lab_pin.sym} 8100 -7420 0 0 {name=p2487 lab=_2372_/CLK }
C {devices/lab_pin.sym} 8100 -7400 0 0 {name=p2488 lab=_2363_/D }
C {devices/lab_pin.sym} 8280 -7420 0 1 {name=p2489 lab=_2363_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -7410 0 0 {name=X_2363_ }
C {devices/lab_pin.sym} 8150 -7280 0 0 {name=p2490 lab=_1314_/A }
C {devices/lab_pin.sym} 8230 -7280 0 1 {name=p2491 lab=_2635_/D }
C {sky130_stdcells/inv_2.sym} 8190 -7280 0 0 {name=X_1314_ }
C {devices/lab_pin.sym} 8100 -7160 0 0 {name=p2492 lab=_2428_/CLK }
C {devices/lab_pin.sym} 8100 -7140 0 0 {name=p2493 lab=_2432_/D }
C {devices/lab_pin.sym} 8280 -7160 0 1 {name=p2494 lab=_1902_/A }
C {sky130_stdcells/dfxtp_4.sym} 8190 -7150 0 0 {name=X_2432_ }
C {devices/lab_pin.sym} 8110 -7040 0 0 {name=p2495 lab=_1420_/Y }
C {devices/lab_pin.sym} 8110 -7000 0 0 {name=p2496 lab=_2291_/X }
C {devices/lab_pin.sym} 8110 -6960 0 0 {name=p2497 lab=_2293_/Y }
C {devices/lab_pin.sym} 8270 -7000 0 1 {name=p2498 lab=_2410_/D }
C {sky130_stdcells/o21ai_4.sym} 8190 -7000 0 0 {name=X_2294_ }
C {devices/lab_pin.sym} 8150 -6860 0 0 {name=p2499 lab=_1245_/A }
C {devices/lab_pin.sym} 8230 -6860 0 1 {name=p2500 lab=_1246_/D }
C {sky130_stdcells/inv_2.sym} 8190 -6860 0 0 {name=X_1245_ }
C {devices/lab_pin.sym} 8130 -6750 0 0 {name=p2501 lab=_1861_/Y }
C {devices/lab_pin.sym} 8130 -6710 0 0 {name=p2502 lab=_1862_/Y }
C {devices/lab_pin.sym} 8250 -6730 0 1 {name=p2503 lab=_2568_/D }
C {sky130_stdcells/nand2_4.sym} 8190 -6730 0 0 {name=X_1863_ }
C {devices/lab_pin.sym} 8130 -6610 0 0 {name=p2504 lab=_1932_/A }
C {devices/lab_pin.sym} 8130 -6570 0 0 {name=p2505 lab=_2529_/Q }
C {devices/lab_pin.sym} 8250 -6590 0 1 {name=p2506 lab=_2525_/D }
C {sky130_stdcells/and2_4.sym} 8190 -6590 0 0 {name=X_1932_ }
C {devices/lab_pin.sym} 8100 -6460 0 0 {name=p2507 lab=_2428_/CLK }
C {devices/lab_pin.sym} 8100 -6440 0 0 {name=p2508 lab=_2415_/D }
C {devices/lab_pin.sym} 8280 -6460 0 1 {name=p2509 lab=_2415_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -6450 0 0 {name=X_2415_ }
C {devices/lab_pin.sym} 8110 -6340 0 0 {name=p2510 lab=_1983_/B }
C {devices/lab_pin.sym} 8110 -6300 0 0 {name=p2511 lab=_2578_/Q }
C {devices/lab_pin.sym} 8110 -6260 0 0 {name=p2512 lab=_1793_/X }
C {devices/lab_pin.sym} 8270 -6300 0 1 {name=p2513 lab=_2586_/D }
C {sky130_stdcells/o21a_4.sym} 8190 -6300 0 0 {name=X_1794_ }
C {devices/lab_pin.sym} 8130 -6170 0 0 {name=p2514 lab=_2345_/Y }
C {devices/lab_pin.sym} 8130 -6130 0 0 {name=p2515 lab=S1_CLK_SELECT }
C {devices/lab_pin.sym} 8250 -6150 0 1 {name=p2516 lab=_2346_/Y }
C {sky130_stdcells/nand2_4.sym} 8190 -6150 0 0 {name=X_2346_ }
C {devices/lab_pin.sym} 8130 -6030 0 0 {name=p2517 lab=_1367_/A }
C {devices/lab_pin.sym} 8130 -5990 0 0 {name=p2518 lab=_1360_/A }
C {devices/lab_pin.sym} 8250 -6010 0 1 {name=p2519 lab=_1228_/Y }
C {sky130_stdcells/nand2_4.sym} 8190 -6010 0 0 {name=X_1228_ }
C {devices/lab_pin.sym} 8150 -5880 0 0 {name=p2520 lab=_1613_/A }
C {devices/lab_pin.sym} 8230 -5880 0 1 {name=p2521 lab=_2278_/A }
C {sky130_stdcells/inv_2.sym} 8190 -5880 0 0 {name=X_2277_ }
C {devices/lab_pin.sym} 8130 -5790 0 0 {name=p2522 lab=_2053_/Y }
C {devices/lab_pin.sym} 8130 -5750 0 0 {name=p2523 lab=_2062_/B }
C {devices/lab_pin.sym} 8130 -5710 0 0 {name=p2524 lab=_2055_/X }
C {devices/lab_pin.sym} 8130 -5670 0 0 {name=p2525 lab=_1993_/C }
C {devices/lab_pin.sym} 8250 -5730 0 1 {name=p2526 lab=_2062_/X }
C {sky130_stdcells/and4_4.sym} 8190 -5730 0 0 {name=X_2062_ }
C {devices/lab_pin.sym} 8130 -5600 0 0 {name=p2527 lab=_2123_/A }
C {devices/lab_pin.sym} 8130 -5560 0 0 {name=p2528 lab=_2335_/A }
C {devices/lab_pin.sym} 8130 -5520 0 0 {name=p2529 lab=_2444_/Q }
C {devices/lab_pin.sym} 8250 -5560 0 1 {name=p2530 lab=_2131_/Y }
C {sky130_stdcells/nand3_4.sym} 8190 -5560 0 0 {name=X_2131_ }
C {devices/lab_pin.sym} 8130 -5430 0 0 {name=p2531 lab=_2420_/Q }
C {devices/lab_pin.sym} 8130 -5390 0 0 {name=p2532 lab=_1703_/A }
C {devices/lab_pin.sym} 8250 -5410 0 1 {name=p2533 lab=_2201_/C }
C {sky130_stdcells/nand2_4.sym} 8190 -5410 0 0 {name=X_2200_ }
C {devices/lab_pin.sym} 8150 -5280 0 0 {name=p2534 lab=clkbuf_4_7_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 8230 -5280 0 1 {name=p2535 lab=_2598_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 8190 -5280 0 0 {name=Xclkbuf_4_6_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 8150 -5160 0 0 {name=p2536 lab=_1254_/X }
C {devices/lab_pin.sym} 8230 -5160 0 1 {name=p2537 lab=_1918_/A }
C {sky130_stdcells/buf_2.sym} 8190 -5160 0 0 {name=X_1915_ }
C {devices/lab_pin.sym} 8130 -5070 0 0 {name=p2538 lab=_1777_/A }
C {devices/lab_pin.sym} 8130 -5030 0 0 {name=p2539 lab=_1777_/B }
C {devices/lab_pin.sym} 8130 -4990 0 0 {name=p2540 lab=_1777_/C }
C {devices/lab_pin.sym} 8130 -4950 0 0 {name=p2541 lab=_1777_/D }
C {devices/lab_pin.sym} 8250 -5010 0 1 {name=p2542 lab=_1783_/D }
C {sky130_stdcells/and4_4.sym} 8190 -5010 0 0 {name=X_1777_ }
C {devices/lab_pin.sym} 8110 -4890 0 0 {name=p2543 lab=ID_toHost }
C {devices/lab_pin.sym} 8110 -4850 0 0 {name=p2544 lab=_2181_/A }
C {devices/lab_pin.sym} 8110 -4810 0 0 {name=p2545 lab=_1617_/Y }
C {devices/lab_pin.sym} 8110 -4770 0 0 {name=p2546 lab=_1845_/Y }
C {devices/lab_pin.sym} 8270 -4830 0 1 {name=p2547 lab=_1846_/X }
C {sky130_stdcells/a211o_4.sym} 8190 -4830 0 0 {name=X_1846_ }
C {devices/lab_pin.sym} 8110 -4720 0 0 {name=p2548 lab=_2102_/A }
C {devices/lab_pin.sym} 8110 -4680 0 0 {name=p2549 lab=_2322_/A }
C {devices/lab_pin.sym} 8110 -4640 0 0 {name=p2550 lab=_1683_/Y }
C {devices/lab_pin.sym} 8110 -4600 0 0 {name=p2551 lab=_2337_/A }
C {devices/lab_pin.sym} 8110 -4560 0 0 {name=p2552 lab=_2328_/X }
C {devices/lab_pin.sym} 8270 -4640 0 1 {name=p2553 lab=_2329_/Y }
C {sky130_stdcells/o32ai_4.sym} 8190 -4640 0 0 {name=X_2329_ }
C {devices/lab_pin.sym} 8110 -4500 0 0 {name=p2554 lab=_1645_/A }
C {devices/lab_pin.sym} 8110 -4460 0 0 {name=p2555 lab=_1308_/C }
C {devices/lab_pin.sym} 8110 -4420 0 0 {name=p2556 lab=_1612_/A }
C {devices/lab_pin.sym} 8270 -4460 0 1 {name=p2557 lab=_1700_/X }
C {sky130_stdcells/a21o_4.sym} 8190 -4460 0 0 {name=X_1700_ }
C {devices/lab_pin.sym} 8150 -4320 0 0 {name=p2558 lab=_1630_/X }
C {devices/lab_pin.sym} 8230 -4320 0 1 {name=p2559 lab=_1751_/A }
C {sky130_stdcells/buf_2.sym} 8190 -4320 0 0 {name=X_1631_ }
C {devices/lab_pin.sym} 8150 -4200 0 0 {name=p2560 lab=_1562_/A }
C {devices/lab_pin.sym} 8230 -4200 0 1 {name=p2561 lab=_1562_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -4200 0 0 {name=X_1562_ }
C {devices/lab_pin.sym} 8130 -4090 0 0 {name=p2562 lab=_1222_/X }
C {devices/lab_pin.sym} 8130 -4050 0 0 {name=p2563 lab=_1492_/Y }
C {devices/lab_pin.sym} 8250 -4070 0 1 {name=p2564 lab=_1493_/Y }
C {sky130_stdcells/nor2_4.sym} 8190 -4070 0 0 {name=X_1493_ }
C {devices/lab_pin.sym} 8110 -3960 0 0 {name=p2565 lab=_2029_/Y }
C {devices/lab_pin.sym} 8110 -3920 0 0 {name=p2566 lab=_2030_/X }
C {devices/lab_pin.sym} 8110 -3880 0 0 {name=p2567 lab=_2043_/C }
C {devices/lab_pin.sym} 8270 -3920 0 1 {name=p2568 lab=_2046_/C }
C {sky130_stdcells/a21oi_4.sym} 8190 -3920 0 0 {name=X_2045_ }
C {devices/lab_pin.sym} 8130 -3790 0 0 {name=p2569 lab=_2104_/A }
C {devices/lab_pin.sym} 8130 -3750 0 0 {name=p2570 lab=ID_fromClient }
C {devices/lab_pin.sym} 8250 -3770 0 1 {name=p2571 lab=_2114_/X }
C {sky130_stdcells/and2_4.sym} 8190 -3770 0 0 {name=X_2114_ }
C {devices/lab_pin.sym} 8150 -3640 0 0 {name=p2572 lab=_1829_/A }
C {devices/lab_pin.sym} 8230 -3640 0 1 {name=p2573 lab=_1829_/Y }
C {sky130_stdcells/inv_2.sym} 8190 -3640 0 0 {name=X_1829_ }
C {devices/lab_pin.sym} 8100 -3520 0 0 {name=p2574 lab=_2388_/CLK }
C {devices/lab_pin.sym} 8100 -3500 0 0 {name=p2575 lab=_2594_/D }
C {devices/lab_pin.sym} 8280 -3520 0 1 {name=p2576 lab=_2594_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -3510 0 0 {name=X_2594_ }
C {devices/lab_pin.sym} 8150 -3380 0 0 {name=p2577 lab=_1613_/Y }
C {devices/lab_pin.sym} 8230 -3380 0 1 {name=p2578 lab=_1614_/X }
C {sky130_stdcells/buf_2.sym} 8190 -3380 0 0 {name=X_1614_ }
C {devices/lab_pin.sym} 8150 -3260 0 0 {name=p2579 lab=_1545_/A }
C {devices/lab_pin.sym} 8230 -3260 0 1 {name=p2580 lab=_1545_/X }
C {sky130_stdcells/buf_2.sym} 8190 -3260 0 0 {name=X_1545_ }
C {devices/lab_pin.sym} 8110 -3160 0 0 {name=p2581 lab=_1456_/X }
C {devices/lab_pin.sym} 8110 -3120 0 0 {name=p2582 lab=_1473_/X }
C {devices/lab_pin.sym} 8110 -3080 0 0 {name=p2583 lab=_1475_/Y }
C {devices/lab_pin.sym} 8270 -3120 0 1 {name=p2584 lab=_1476_/Y }
C {sky130_stdcells/o21ai_4.sym} 8190 -3120 0 0 {name=X_1476_ }
C {devices/lab_pin.sym} 8130 -3000 0 0 {name=p2585 lab=_2028_/A }
C {devices/lab_pin.sym} 8130 -2960 0 0 {name=p2586 lab=_2044_/B }
C {devices/lab_pin.sym} 8130 -2920 0 0 {name=p2587 lab=_2013_/D }
C {devices/lab_pin.sym} 8250 -2960 0 1 {name=p2588 lab=_2028_/X }
C {sky130_stdcells/and3_4.sym} 8190 -2960 0 0 {name=X_2028_ }
C {devices/lab_pin.sym} 8130 -2850 0 0 {name=p2589 lab=_1318_/B }
C {devices/lab_pin.sym} 8130 -2810 0 0 {name=p2590 lab=_1335_/C }
C {devices/lab_pin.sym} 8130 -2770 0 0 {name=p2591 lab=_1242_/C }
C {devices/lab_pin.sym} 8130 -2730 0 0 {name=p2592 lab=_1329_/X }
C {devices/lab_pin.sym} 8250 -2790 0 1 {name=p2593 lab=_1330_/X }
C {sky130_stdcells/and4_4.sym} 8190 -2790 0 0 {name=X_1330_ }
C {devices/lab_pin.sym} 8130 -2670 0 0 {name=p2594 lab=_1256_/Y }
C {devices/lab_pin.sym} 8130 -2630 0 0 {name=p2595 lab=_1225_/X }
C {devices/lab_pin.sym} 8130 -2590 0 0 {name=p2596 lab=_1257_/X }
C {devices/lab_pin.sym} 8130 -2550 0 0 {name=p2597 lab=_1260_/Y }
C {devices/lab_pin.sym} 8250 -2610 0 1 {name=p2598 lab=_1261_/Y }
C {sky130_stdcells/nor4_4.sym} 8190 -2610 0 0 {name=X_1261_ }
C {devices/lab_pin.sym} 8110 -2480 0 0 {name=p2599 lab=_2593_/Q }
C {devices/lab_pin.sym} 8110 -2440 0 0 {name=p2600 lab=_1216_/B }
C {devices/lab_pin.sym} 8110 -2400 0 0 {name=p2601 lab=_1191_/X }
C {devices/lab_pin.sym} 8270 -2440 0 1 {name=p2602 lab=_1192_/Y }
C {sky130_stdcells/o21ai_4.sym} 8190 -2440 0 0 {name=X_1192_ }
C {devices/lab_pin.sym} 8100 -2300 0 0 {name=p2603 lab=_2570_/CLK }
C {devices/lab_pin.sym} 8100 -2280 0 0 {name=p2604 lab=_1215_/Y }
C {devices/lab_pin.sym} 8280 -2300 0 1 {name=p2605 lab=_1206_/A }
C {sky130_stdcells/dfxtp_4.sym} 8190 -2290 0 0 {name=X_2646_ }
C {devices/lab_pin.sym} 8100 -2160 0 0 {name=p2606 lab=_2581_/CLK }
C {devices/lab_pin.sym} 8100 -2140 0 0 {name=p2607 lab=_1817_/X }
C {devices/lab_pin.sym} 8280 -2160 0 1 {name=p2608 lab=_2577_/Q }
C {sky130_stdcells/dfxtp_4.sym} 8190 -2150 0 0 {name=X_2577_ }
C {devices/lab_pin.sym} 8130 -2030 0 0 {name=p2609 lab=_1528_/A }
C {devices/lab_pin.sym} 8130 -1990 0 0 {name=p2610 lab=_1445_/A }
C {devices/lab_pin.sym} 8250 -2010 0 1 {name=p2611 lab=_1528_/Y }
C {sky130_stdcells/nor2_4.sym} 8190 -2010 0 0 {name=X_1528_ }
C {devices/lab_pin.sym} 8150 -1880 0 0 {name=p2612 lab=_1459_/A }
C {devices/lab_pin.sym} 8230 -1880 0 1 {name=p2613 lab=_2266_/A }
C {sky130_stdcells/buf_2.sym} 8190 -1880 0 0 {name=X_1459_ }
C {sky130_stdcells/decap_3.sym} 8190 -1730 0 0 {name=XPHY_91 }
C {sky130_stdcells/decap_3.sym} 3530 -21890 0 0 {name=XPHY_80 }
C {devices/lab_pin.sym} 3440 -21740 0 0 {name=p2614 lab=_2428_/CLK }
C {devices/lab_pin.sym} 3440 -21720 0 0 {name=p2615 lab=_2431_/D }
C {devices/lab_pin.sym} 3620 -21740 0 1 {name=p2616 lab=_2431_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -21730 0 0 {name=X_2431_ }
C {devices/lab_pin.sym} 3440 -21600 0 0 {name=p2617 lab=_2519_/CLK }
C {devices/lab_pin.sym} 3440 -21580 0 0 {name=p2618 lab=_2500_/D }
C {devices/lab_pin.sym} 3620 -21600 0 1 {name=p2619 lab=MACRO_WR_SELECT[1] }
C {sky130_stdcells/dfxtp_4.sym} 3530 -21590 0 0 {name=X_2500_ }
C {devices/lab_pin.sym} 3490 -21460 0 0 {name=p2620 lab=SCSN_fromHost }
C {devices/lab_pin.sym} 3570 -21460 0 1 {name=p2621 lab=SCSN_toClient }
C {sky130_stdcells/buf_2.sym} 3530 -21460 0 0 {name=X_2362_ }
C {devices/lab_pin.sym} 3450 -21360 0 0 {name=p2622 lab=_1308_/C }
C {devices/lab_pin.sym} 3450 -21320 0 0 {name=p2623 lab=_1308_/A }
C {devices/lab_pin.sym} 3450 -21280 0 0 {name=p2624 lab=_1312_/Y }
C {devices/lab_pin.sym} 3610 -21320 0 1 {name=p2625 lab=_1314_/A }
C {sky130_stdcells/o21ai_4.sym} 3530 -21320 0 0 {name=X_1313_ }
C {devices/lab_pin.sym} 3470 -21190 0 0 {name=p2626 lab=_1318_/A }
C {devices/lab_pin.sym} 3470 -21150 0 0 {name=p2627 lab=_1244_/B }
C {devices/lab_pin.sym} 3590 -21170 0 1 {name=p2628 lab=_1245_/A }
C {sky130_stdcells/nand2_4.sym} 3530 -21170 0 0 {name=X_1244_ }
C {devices/lab_pin.sym} 3470 -21060 0 0 {name=p2629 lab=_2292_/X }
C {devices/lab_pin.sym} 3470 -21020 0 0 {name=p2630 lab=_2298_/B }
C {devices/lab_pin.sym} 3470 -20980 0 0 {name=p2631 lab=_2410_/Q }
C {devices/lab_pin.sym} 3590 -21020 0 1 {name=p2632 lab=_2293_/Y }
C {sky130_stdcells/nand3_4.sym} 3530 -21020 0 0 {name=X_2293_ }
C {devices/lab_pin.sym} 3440 -20880 0 0 {name=p2633 lab=_2626_/CLK }
C {devices/lab_pin.sym} 3440 -20860 0 0 {name=p2634 lab=_2629_/D }
C {devices/lab_pin.sym} 3620 -20880 0 1 {name=p2635 lab=_2629_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -20870 0 0 {name=X_2629_ }
C {devices/lab_pin.sym} 3470 -20750 0 0 {name=p2636 lab=_1762_/A }
C {devices/lab_pin.sym} 3470 -20710 0 0 {name=p2637 lab=_1862_/B }
C {devices/lab_pin.sym} 3590 -20730 0 1 {name=p2638 lab=_1862_/Y }
C {sky130_stdcells/nand2_4.sym} 3530 -20730 0 0 {name=X_1862_ }
C {devices/lab_pin.sym} 3450 -20620 0 0 {name=p2639 lab=_1788_/X }
C {devices/lab_pin.sym} 3450 -20580 0 0 {name=p2640 lab=_2266_/A }
C {devices/lab_pin.sym} 3450 -20540 0 0 {name=p2641 lab=_2326_/A }
C {devices/lab_pin.sym} 3610 -20580 0 1 {name=p2642 lab=_1793_/X }
C {sky130_stdcells/o21a_4.sym} 3530 -20580 0 0 {name=X_1793_ }
C {devices/lab_pin.sym} 3470 -20450 0 0 {name=p2643 lab=_1932_/A }
C {devices/lab_pin.sym} 3470 -20410 0 0 {name=p2644 lab=_1931_/B }
C {devices/lab_pin.sym} 3590 -20430 0 1 {name=p2645 lab=_2526_/D }
C {sky130_stdcells/and2_4.sym} 3530 -20430 0 0 {name=X_1931_ }
C {devices/lab_pin.sym} 3440 -20300 0 0 {name=p2646 lab=_2428_/CLK }
C {devices/lab_pin.sym} 3440 -20280 0 0 {name=p2647 lab=_2285_/Y }
C {devices/lab_pin.sym} 3620 -20300 0 1 {name=p2648 lab=_2151_/B }
C {sky130_stdcells/dfxtp_4.sym} 3530 -20290 0 0 {name=X_2414_ }
C {devices/lab_pin.sym} 3490 -20160 0 0 {name=p2649 lab=S1_CLK_IN }
C {devices/lab_pin.sym} 3570 -20160 0 1 {name=p2650 lab=_2345_/Y }
C {sky130_stdcells/inv_2.sym} 3530 -20160 0 0 {name=X_2345_ }
C {devices/lab_pin.sym} 3470 -20050 0 0 {name=p2651 lab=_1295_/A }
C {devices/lab_pin.sym} 3470 -20010 0 0 {name=p2652 lab=_1299_/A }
C {devices/lab_pin.sym} 3590 -20030 0 1 {name=p2653 lab=_1257_/A }
C {sky130_stdcells/nand2_4.sym} 3530 -20030 0 0 {name=X_1227_ }
C {devices/lab_pin.sym} 3490 -19900 0 0 {name=p2654 lab=_1581_/X }
C {devices/lab_pin.sym} 3570 -19900 0 1 {name=p2655 lab=_2276_/X }
C {sky130_stdcells/buf_2.sym} 3530 -19900 0 0 {name=X_2276_ }
C {devices/lab_pin.sym} 3490 -19780 0 0 {name=p2656 lab=clkbuf_3_5_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 3570 -19780 0 1 {name=p2657 lab=_2390_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 3530 -19780 0 0 {name=Xclkbuf_4_11_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 3450 -19700 0 0 {name=p2658 lab=_2058_/X }
C {devices/lab_pin.sym} 3450 -19660 0 0 {name=p2659 lab=_2060_/Y }
C {devices/lab_pin.sym} 3450 -19620 0 0 {name=p2660 lab=_2062_/B }
C {devices/lab_pin.sym} 3450 -19580 0 0 {name=p2661 lab=_2055_/X }
C {devices/lab_pin.sym} 3450 -19550 0 0 {name=p2662 lab=_1993_/C }
C {devices/lab_pin.sym} 3610 -19620 0 1 {name=p2663 lab=_2061_/Y }
C {sky130_stdcells/a41oi_4.sym} 3530 -19620 0 0 {name=X_2061_ }
C {devices/lab_pin.sym} 3470 -19480 0 0 {name=p2664 lab=_1840_/B }
C {devices/lab_pin.sym} 3470 -19440 0 0 {name=p2665 lab=_2121_/X }
C {devices/lab_pin.sym} 3470 -19400 0 0 {name=p2666 lab=_2268_/A }
C {devices/lab_pin.sym} 3590 -19440 0 1 {name=p2667 lab=_2130_/Y }
C {sky130_stdcells/nand3_4.sym} 3530 -19440 0 0 {name=X_2130_ }
C {devices/lab_pin.sym} 3470 -19310 0 0 {name=p2668 lab=_1930_/A }
C {devices/lab_pin.sym} 3470 -19270 0 0 {name=p2669 lab=_1914_/B }
C {devices/lab_pin.sym} 3590 -19290 0 1 {name=p2670 lab=_2537_/D }
C {sky130_stdcells/nor2_4.sym} 3530 -19290 0 0 {name=X_1914_ }
C {devices/lab_pin.sym} 3450 -19190 0 0 {name=p2671 lab=_1512_/Y }
C {devices/lab_pin.sym} 3450 -19150 0 0 {name=p2672 lab=_1764_/A }
C {devices/lab_pin.sym} 3450 -19110 0 0 {name=p2673 lab=_1494_/B }
C {devices/lab_pin.sym} 3450 -19070 0 0 {name=p2674 lab=_1771_/Y }
C {devices/lab_pin.sym} 3610 -19130 0 1 {name=p2675 lab=_1777_/D }
C {sky130_stdcells/a22oi_4.sym} 3530 -19130 0 0 {name=X_1776_ }
C {devices/lab_pin.sym} 3470 -18990 0 0 {name=p2676 lab=_2175_/B }
C {devices/lab_pin.sym} 3470 -18950 0 0 {name=p2677 lab=_1845_/B }
C {devices/lab_pin.sym} 3590 -18970 0 1 {name=p2678 lab=_1845_/Y }
C {sky130_stdcells/nor2_4.sym} 3530 -18970 0 0 {name=X_1845_ }
C {devices/lab_pin.sym} 3450 -18860 0 0 {name=p2679 lab=_1187_/A }
C {devices/lab_pin.sym} 3450 -18820 0 0 {name=p2680 lab=_1680_/B }
C {devices/lab_pin.sym} 3450 -18780 0 0 {name=p2681 lab=_1781_/A }
C {devices/lab_pin.sym} 3610 -18820 0 1 {name=p2682 lab=_2328_/X }
C {sky130_stdcells/a21o_4.sym} 3530 -18820 0 0 {name=X_2328_ }
C {devices/lab_pin.sym} 3450 -18720 0 0 {name=p2683 lab=_2243_/Y }
C {devices/lab_pin.sym} 3450 -18680 0 0 {name=p2684 lab=_2257_/Y }
C {devices/lab_pin.sym} 3450 -18640 0 0 {name=p2685 lab=_2258_/X }
C {devices/lab_pin.sym} 3450 -18600 0 0 {name=p2686 lab=_1911_/B }
C {devices/lab_pin.sym} 3450 -18560 0 0 {name=p2687 lab=_2248_/X }
C {devices/lab_pin.sym} 3610 -18640 0 1 {name=p2688 lab=_2428_/D }
C {sky130_stdcells/o32ai_4.sym} 3530 -18640 0 0 {name=X_2259_ }
C {devices/lab_pin.sym} 3490 -18480 0 0 {name=p2689 lab=_2447_/Q }
C {devices/lab_pin.sym} 3570 -18480 0 1 {name=p2690 lab=_1630_/X }
C {sky130_stdcells/buf_2.sym} 3530 -18480 0 0 {name=X_1630_ }
C {devices/lab_pin.sym} 3470 -18370 0 0 {name=p2691 lab=_1428_/C }
C {devices/lab_pin.sym} 3470 -18330 0 0 {name=p2692 lab=_1669_/B }
C {devices/lab_pin.sym} 3590 -18350 0 1 {name=p2693 lab=_1562_/A }
C {sky130_stdcells/nand2_4.sym} 3530 -18350 0 0 {name=X_1561_ }
C {devices/lab_pin.sym} 3450 -18250 0 0 {name=p2694 lab=_2609_/Q }
C {devices/lab_pin.sym} 3450 -18210 0 0 {name=p2695 lab=_1489_/X }
C {devices/lab_pin.sym} 3450 -18170 0 0 {name=p2696 lab=_1491_/Y }
C {devices/lab_pin.sym} 3450 -18130 0 0 {name=p2697 lab=_1449_/B }
C {devices/lab_pin.sym} 3610 -18190 0 1 {name=p2698 lab=_1492_/Y }
C {sky130_stdcells/a22oi_4.sym} 3530 -18190 0 0 {name=X_1492_ }
C {devices/lab_pin.sym} 3470 -18060 0 0 {name=p2699 lab=_2044_/A }
C {devices/lab_pin.sym} 3470 -18020 0 0 {name=p2700 lab=_2044_/B }
C {devices/lab_pin.sym} 3470 -17980 0 0 {name=p2701 lab=_2044_/C }
C {devices/lab_pin.sym} 3590 -18020 0 1 {name=p2702 lab=_2044_/X }
C {sky130_stdcells/and3_4.sym} 3530 -18020 0 0 {name=X_2044_ }
C {devices/lab_pin.sym} 3470 -17890 0 0 {name=p2703 lab=_2104_/A }
C {devices/lab_pin.sym} 3470 -17850 0 0 {name=p2704 lab=_2113_/B }
C {devices/lab_pin.sym} 3590 -17870 0 1 {name=p2705 lab=_2113_/X }
C {sky130_stdcells/and2_4.sym} 3530 -17870 0 0 {name=X_2113_ }
C {devices/lab_pin.sym} 3450 -17760 0 0 {name=p2706 lab=_1656_/X }
C {devices/lab_pin.sym} 3450 -17720 0 0 {name=p2707 lab=_1397_/A }
C {devices/lab_pin.sym} 3450 -17680 0 0 {name=p2708 lab=_2166_/A }
C {devices/lab_pin.sym} 3610 -17720 0 1 {name=p2709 lab=_1759_/Y }
C {sky130_stdcells/a21oi_4.sym} 3530 -17720 0 0 {name=X_1759_ }
C {devices/lab_pin.sym} 3450 -17600 0 0 {name=p2710 lab=_1808_/Y }
C {devices/lab_pin.sym} 3450 -17560 0 0 {name=p2711 lab=_2455_/Q }
C {devices/lab_pin.sym} 3450 -17520 0 0 {name=p2712 lab=_1827_/X }
C {devices/lab_pin.sym} 3610 -17560 0 1 {name=p2713 lab=_2572_/D }
C {sky130_stdcells/o21a_4.sym} 3530 -17560 0 0 {name=X_1828_ }
C {devices/lab_pin.sym} 3440 -17420 0 0 {name=p2714 lab=_2590_/CLK }
C {devices/lab_pin.sym} 3440 -17400 0 0 {name=p2715 lab=_2593_/D }
C {devices/lab_pin.sym} 3620 -17420 0 1 {name=p2716 lab=_2593_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -17410 0 0 {name=X_2593_ }
C {devices/lab_pin.sym} 3470 -17310 0 0 {name=p2717 lab=_1613_/A }
C {devices/lab_pin.sym} 3470 -17270 0 0 {name=p2718 lab=_1651_/A }
C {devices/lab_pin.sym} 3470 -17230 0 0 {name=p2719 lab=_1667_/C }
C {devices/lab_pin.sym} 3470 -17190 0 0 {name=p2720 lab=_1667_/D }
C {devices/lab_pin.sym} 3590 -17250 0 1 {name=p2721 lab=_1613_/Y }
C {sky130_stdcells/nand4_4.sym} 3530 -17250 0 0 {name=X_1613_ }
C {devices/lab_pin.sym} 3450 -17120 0 0 {name=p2722 lab=_1537_/X }
C {devices/lab_pin.sym} 3450 -17080 0 0 {name=p2723 lab=_1548_/D }
C {devices/lab_pin.sym} 3450 -17040 0 0 {name=p2724 lab=_1435_/Y }
C {devices/lab_pin.sym} 3610 -17080 0 1 {name=p2725 lab=_1544_/Y }
C {sky130_stdcells/o21ai_4.sym} 3530 -17080 0 0 {name=X_1544_ }
C {devices/lab_pin.sym} 3450 -16980 0 0 {name=p2726 lab=_1456_/X }
C {devices/lab_pin.sym} 3450 -16940 0 0 {name=p2727 lab=_1440_/B }
C {devices/lab_pin.sym} 3450 -16900 0 0 {name=p2728 lab=_1473_/B }
C {devices/lab_pin.sym} 3450 -16860 0 0 {name=p2729 lab=_1438_/A }
C {devices/lab_pin.sym} 3450 -16830 0 0 {name=p2730 lab=_2340_/C }
C {devices/lab_pin.sym} 3610 -16900 0 1 {name=p2731 lab=_1475_/Y }
C {sky130_stdcells/a41oi_4.sym} 3530 -16900 0 0 {name=X_1475_ }
C {devices/lab_pin.sym} 3490 -16740 0 0 {name=p2732 lab=_1270_/A }
C {devices/lab_pin.sym} 3570 -16740 0 1 {name=p2733 lab=_2044_/B }
C {sky130_stdcells/buf_2.sym} 3530 -16740 0 0 {name=X_2027_ }
C {devices/lab_pin.sym} 3490 -16620 0 0 {name=p2734 lab=_2096_/A }
C {devices/lab_pin.sym} 3570 -16620 0 1 {name=p2735 lab=_1191_/X }
C {sky130_stdcells/buf_2.sym} 3530 -16620 0 0 {name=X_1191_ }
C {devices/lab_pin.sym} 3470 -16530 0 0 {name=p2736 lab=_1258_/Y }
C {devices/lab_pin.sym} 3470 -16490 0 0 {name=p2737 lab=_1243_/X }
C {devices/lab_pin.sym} 3470 -16450 0 0 {name=p2738 lab=_1246_/D }
C {devices/lab_pin.sym} 3470 -16410 0 0 {name=p2739 lab=_1292_/C }
C {devices/lab_pin.sym} 3590 -16470 0 1 {name=p2740 lab=_1260_/Y }
C {sky130_stdcells/nand4_4.sym} 3530 -16470 0 0 {name=X_1260_ }
C {devices/lab_pin.sym} 3490 -16320 0 0 {name=p2741 lab=clkbuf_3_1_0_m1_clk_local/A }
C {devices/lab_pin.sym} 3570 -16320 0 1 {name=p2742 lab=clkbuf_4_3_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 3530 -16320 0 0 {name=Xclkbuf_3_1_0_m1_clk_local }
C {devices/lab_pin.sym} 3440 -16200 0 0 {name=p2743 lab=_2570_/CLK }
C {devices/lab_pin.sym} 3440 -16180 0 0 {name=p2744 lab=_2645_/D }
C {devices/lab_pin.sym} 3620 -16200 0 1 {name=p2745 lab=_2645_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -16190 0 0 {name=X_2645_ }
C {devices/lab_pin.sym} 3490 -16060 0 0 {name=p2746 lab=_1526_/Y }
C {devices/lab_pin.sym} 3570 -16060 0 1 {name=p2747 lab=_1527_/Y }
C {sky130_stdcells/inv_2.sym} 3530 -16060 0 0 {name=X_1527_ }
C {devices/lab_pin.sym} 3440 -15940 0 0 {name=p2748 lab=_2581_/CLK }
C {devices/lab_pin.sym} 3440 -15920 0 0 {name=p2749 lab=_2576_/D }
C {devices/lab_pin.sym} 3620 -15940 0 1 {name=p2750 lab=_2576_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -15930 0 0 {name=X_2576_ }
C {devices/lab_pin.sym} 3450 -15820 0 0 {name=p2751 lab=_1379_/X }
C {devices/lab_pin.sym} 3450 -15780 0 0 {name=p2752 lab=_1385_/D }
C {devices/lab_pin.sym} 3450 -15740 0 0 {name=p2753 lab=_2621_/Q }
C {devices/lab_pin.sym} 3610 -15780 0 1 {name=p2754 lab=_1390_/C }
C {sky130_stdcells/a21oi_4.sym} 3530 -15780 0 0 {name=X_1389_ }
C {devices/lab_pin.sym} 3450 -15660 0 0 {name=p2755 lab=_1438_/B }
C {devices/lab_pin.sym} 3450 -15620 0 0 {name=p2756 lab=_1457_/X }
C {devices/lab_pin.sym} 3450 -15580 0 0 {name=p2757 lab=_1452_/Y }
C {devices/lab_pin.sym} 3610 -15620 0 1 {name=p2758 lab=_1458_/Y }
C {sky130_stdcells/o21ai_4.sym} 3530 -15620 0 0 {name=X_1458_ }
C {sky130_stdcells/decap_3.sym} 3530 -15450 0 0 {name=XPHY_92 }
C {sky130_stdcells/decap_3.sym} 3530 -15270 0 0 {name=XPHY_81 }
C {sky130_stdcells/decap_3.sym} 3530 -15090 0 0 {name=XPHY_70 }
C {devices/lab_pin.sym} 3490 -14940 0 0 {name=p2759 lab=SCLK_fromHost }
C {devices/lab_pin.sym} 3570 -14940 0 1 {name=p2760 lab=SCLK_toClient }
C {sky130_stdcells/buf_2.sym} 3530 -14940 0 0 {name=X_2361_ }
C {devices/lab_pin.sym} 3440 -14820 0 0 {name=p2761 lab=_2428_/CLK }
C {devices/lab_pin.sym} 3440 -14800 0 0 {name=p2762 lab=_2254_/Y }
C {devices/lab_pin.sym} 3620 -14820 0 1 {name=p2763 lab=_2154_/B }
C {sky130_stdcells/dfxtp_4.sym} 3530 -14810 0 0 {name=X_2430_ }
C {devices/lab_pin.sym} 3490 -14680 0 0 {name=p2764 lab=_1243_/A }
C {devices/lab_pin.sym} 3570 -14680 0 1 {name=p2765 lab=_1243_/X }
C {sky130_stdcells/buf_2.sym} 3530 -14680 0 0 {name=X_1243_ }
C {devices/lab_pin.sym} 3450 -14600 0 0 {name=p2766 lab=_1308_/C }
C {devices/lab_pin.sym} 3450 -14560 0 0 {name=p2767 lab=_1318_/B }
C {devices/lab_pin.sym} 3450 -14520 0 0 {name=p2768 lab=_1316_/D }
C {devices/lab_pin.sym} 3450 -14480 0 0 {name=p2769 lab=_1246_/D }
C {devices/lab_pin.sym} 3450 -14450 0 0 {name=p2770 lab=_1274_/X }
C {devices/lab_pin.sym} 3610 -14520 0 1 {name=p2771 lab=_1312_/Y }
C {sky130_stdcells/a41oi_4.sym} 3530 -14520 0 0 {name=X_1312_ }
C {devices/lab_pin.sym} 3490 -14360 0 0 {name=p2772 lab=_2290_/Y }
C {devices/lab_pin.sym} 3570 -14360 0 1 {name=p2773 lab=_2292_/X }
C {sky130_stdcells/buf_2.sym} 3530 -14360 0 0 {name=X_2292_ }
C {devices/lab_pin.sym} 3440 -14240 0 0 {name=p2774 lab=_2626_/CLK }
C {devices/lab_pin.sym} 3440 -14220 0 0 {name=p2775 lab=_2628_/D }
C {devices/lab_pin.sym} 3620 -14240 0 1 {name=p2776 lab=_2628_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -14230 0 0 {name=X_2628_ }
C {devices/lab_pin.sym} 3440 -14100 0 0 {name=p2777 lab=_2554_/CLK }
C {devices/lab_pin.sym} 3440 -14080 0 0 {name=p2778 lab=_2559_/D }
C {devices/lab_pin.sym} 3620 -14100 0 1 {name=p2779 lab=_2559_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -14090 0 0 {name=X_2559_ }
C {devices/lab_pin.sym} 3470 -13970 0 0 {name=p2780 lab=_1930_/A }
C {devices/lab_pin.sym} 3470 -13930 0 0 {name=p2781 lab=_1929_/Y }
C {devices/lab_pin.sym} 3590 -13950 0 1 {name=p2782 lab=_2527_/D }
C {sky130_stdcells/nor2_4.sym} 3530 -13950 0 0 {name=X_1930_ }
C {devices/lab_pin.sym} 3470 -13840 0 0 {name=p2783 lab=_1859_/Y }
C {devices/lab_pin.sym} 3470 -13800 0 0 {name=p2784 lab=_1673_/Y }
C {devices/lab_pin.sym} 3470 -13760 0 0 {name=p2785 lab=_1860_/X }
C {devices/lab_pin.sym} 3590 -13800 0 1 {name=p2786 lab=_1861_/Y }
C {sky130_stdcells/nand3_4.sym} 3530 -13800 0 0 {name=X_1861_ }
C {devices/lab_pin.sym} 3450 -13680 0 0 {name=p2787 lab=_1983_/B }
C {devices/lab_pin.sym} 3450 -13640 0 0 {name=p2788 lab=_2579_/Q }
C {devices/lab_pin.sym} 3450 -13600 0 0 {name=p2789 lab=_1791_/X }
C {devices/lab_pin.sym} 3610 -13640 0 1 {name=p2790 lab=_1792_/X }
C {sky130_stdcells/o21a_4.sym} 3530 -13640 0 0 {name=X_1792_ }
C {devices/lab_pin.sym} 3440 -13500 0 0 {name=p2791 lab=_2445_/CLK }
C {devices/lab_pin.sym} 3440 -13480 0 0 {name=p2792 lab=_2413_/D }
C {devices/lab_pin.sym} 3620 -13500 0 1 {name=p2793 lab=_2174_/B }
C {sky130_stdcells/dfxtp_4.sym} 3530 -13490 0 0 {name=X_2413_ }
C {devices/lab_pin.sym} 3450 -13380 0 0 {name=p2794 lab=_2342_/Y }
C {devices/lab_pin.sym} 3450 -13340 0 0 {name=p2795 lab=M1_CLK_SELECT }
C {devices/lab_pin.sym} 3450 -13300 0 0 {name=p2796 lab=_2343_/Y }
C {devices/lab_pin.sym} 3610 -13340 0 1 {name=p2797 lab=m1_clk_local }
C {sky130_stdcells/a21oi_4.sym} 3530 -13340 0 0 {name=X_2344_ }
C {devices/lab_pin.sym} 3470 -13210 0 0 {name=p2798 lab=_2636_/Q }
C {devices/lab_pin.sym} 3470 -13170 0 0 {name=p2799 lab=_2635_/Q }
C {devices/lab_pin.sym} 3590 -13190 0 1 {name=p2800 lab=_1226_/Y }
C {sky130_stdcells/nand2_4.sym} 3530 -13190 0 0 {name=X_1226_ }
C {devices/lab_pin.sym} 3450 -13100 0 0 {name=p2801 lab=_2144_/Y }
C {devices/lab_pin.sym} 3450 -13060 0 0 {name=p2802 lab=_1649_/B }
C {devices/lab_pin.sym} 3450 -13020 0 0 {name=p2803 lab=_2270_/X }
C {devices/lab_pin.sym} 3450 -12980 0 0 {name=p2804 lab=_1948_/Y }
C {devices/lab_pin.sym} 3450 -12940 0 0 {name=p2805 lab=_2263_/X }
C {devices/lab_pin.sym} 3610 -13020 0 1 {name=p2806 lab=_2419_/D }
C {sky130_stdcells/o32ai_4.sym} 3530 -13020 0 0 {name=X_2275_ }
C {devices/lab_pin.sym} 3470 -12870 0 0 {name=p2807 lab=_2060_/A }
C {devices/lab_pin.sym} 3470 -12830 0 0 {name=p2808 lab=_2060_/B }
C {devices/lab_pin.sym} 3590 -12850 0 1 {name=p2809 lab=_2060_/Y }
C {sky130_stdcells/nor2_4.sym} 3530 -12850 0 0 {name=X_2060_ }
C {devices/lab_pin.sym} 3490 -12720 0 0 {name=p2810 lab=_1913_/A }
C {devices/lab_pin.sym} 3570 -12720 0 1 {name=p2811 lab=_1914_/B }
C {sky130_stdcells/inv_2.sym} 3530 -12720 0 0 {name=X_1913_ }
C {devices/lab_pin.sym} 3490 -12600 0 0 {name=p2812 lab=_1844_/A }
C {devices/lab_pin.sym} 3570 -12600 0 1 {name=p2813 lab=_1845_/B }
C {sky130_stdcells/inv_2.sym} 3530 -12600 0 0 {name=X_1844_ }
C {devices/lab_pin.sym} 3450 -12510 0 0 {name=p2814 lab=_1499_/Y }
C {devices/lab_pin.sym} 3450 -12470 0 0 {name=p2815 lab=_1773_/A }
C {devices/lab_pin.sym} 3450 -12430 0 0 {name=p2816 lab=_1456_/X }
C {devices/lab_pin.sym} 3450 -12390 0 0 {name=p2817 lab=_1766_/B }
C {devices/lab_pin.sym} 3610 -12450 0 1 {name=p2818 lab=_1777_/C }
C {sky130_stdcells/a22oi_4.sym} 3530 -12450 0 0 {name=X_1775_ }
C {devices/lab_pin.sym} 3450 -12340 0 0 {name=p2819 lab=_1222_/A }
C {devices/lab_pin.sym} 3450 -12300 0 0 {name=p2820 lab=_1218_/B }
C {devices/lab_pin.sym} 3450 -12260 0 0 {name=p2821 lab=_1680_/B }
C {devices/lab_pin.sym} 3450 -12220 0 0 {name=p2822 lab=_1683_/Y }
C {devices/lab_pin.sym} 3450 -12180 0 0 {name=p2823 lab=_2326_/Y }
C {devices/lab_pin.sym} 3610 -12260 0 1 {name=p2824 lab=_2387_/D }
C {sky130_stdcells/o41ai_4.sym} 3530 -12260 0 0 {name=X_2327_ }
C {devices/lab_pin.sym} 3490 -12100 0 0 {name=p2825 lab=_2246_/Y }
C {devices/lab_pin.sym} 3570 -12100 0 1 {name=p2826 lab=_2258_/X }
C {sky130_stdcells/buf_2.sym} 3530 -12100 0 0 {name=X_2258_ }
C {devices/lab_pin.sym} 3450 -12000 0 0 {name=p2827 lab=_1207_/Y }
C {devices/lab_pin.sym} 3450 -11960 0 0 {name=p2828 lab=_1187_/X }
C {devices/lab_pin.sym} 3450 -11920 0 0 {name=p2829 lab=_1208_/Y }
C {devices/lab_pin.sym} 3610 -11960 0 1 {name=p2830 lab=_2647_/D }
C {sky130_stdcells/a21oi_4.sym} 3530 -11960 0 0 {name=X_1209_ }
C {devices/lab_pin.sym} 3470 -11830 0 0 {name=p2831 lab=_2146_/A }
C {devices/lab_pin.sym} 3470 -11790 0 0 {name=p2832 lab=THREAD_COUNT[2] }
C {devices/lab_pin.sym} 3590 -11810 0 1 {name=p2833 lab=_2189_/Y }
C {sky130_stdcells/nand2_4.sym} 3530 -11810 0 0 {name=X_2189_ }
C {devices/lab_pin.sym} 3490 -11680 0 0 {name=p2834 lab=_1428_/D }
C {devices/lab_pin.sym} 3570 -11680 0 1 {name=p2835 lab=_1669_/B }
C {sky130_stdcells/buf_2.sym} 3530 -11680 0 0 {name=X_1560_ }
C {devices/lab_pin.sym} 3470 -11570 0 0 {name=p2836 lab=_1870_/X }
C {devices/lab_pin.sym} 3470 -11530 0 0 {name=p2837 lab=_2103_/Y }
C {devices/lab_pin.sym} 3590 -11550 0 1 {name=p2838 lab=_2112_/Y }
C {sky130_stdcells/nand2_4.sym} 3530 -11550 0 0 {name=X_2112_ }
C {devices/lab_pin.sym} 3450 -11460 0 0 {name=p2839 lab=_2609_/Q }
C {devices/lab_pin.sym} 3450 -11420 0 0 {name=p2840 lab=_1451_/X }
C {devices/lab_pin.sym} 3450 -11380 0 0 {name=p2841 lab=_1487_/Y }
C {devices/lab_pin.sym} 3450 -11340 0 0 {name=p2842 lab=_1490_/Y }
C {devices/lab_pin.sym} 3450 -11300 0 0 {name=p2843 lab=_1445_/D }
C {devices/lab_pin.sym} 3610 -11380 0 1 {name=p2844 lab=_1491_/Y }
C {sky130_stdcells/o32ai_4.sym} 3530 -11380 0 0 {name=X_1491_ }
C {devices/lab_pin.sym} 3470 -11250 0 0 {name=p2845 lab=_2030_/X }
C {devices/lab_pin.sym} 3470 -11210 0 0 {name=p2846 lab=_2029_/Y }
C {devices/lab_pin.sym} 3470 -11170 0 0 {name=p2847 lab=_2043_/C }
C {devices/lab_pin.sym} 3470 -11130 0 0 {name=p2848 lab=_2043_/D }
C {devices/lab_pin.sym} 3590 -11190 0 1 {name=p2849 lab=_2044_/C }
C {sky130_stdcells/nand4_4.sym} 3530 -11190 0 0 {name=X_2043_ }
C {devices/lab_pin.sym} 3450 -11060 0 0 {name=p2850 lab=_2572_/Q }
C {devices/lab_pin.sym} 3450 -11020 0 0 {name=p2851 lab=_2461_/Q }
C {devices/lab_pin.sym} 3450 -10980 0 0 {name=p2852 lab=_2257_/A }
C {devices/lab_pin.sym} 3610 -11020 0 1 {name=p2853 lab=_1827_/X }
C {sky130_stdcells/o21a_4.sym} 3530 -11020 0 0 {name=X_1827_ }
C {devices/lab_pin.sym} 3450 -10900 0 0 {name=p2854 lab=_1742_/Y }
C {devices/lab_pin.sym} 3450 -10860 0 0 {name=p2855 lab=_1756_/Y }
C {devices/lab_pin.sym} 3450 -10820 0 0 {name=p2856 lab=_1757_/Y }
C {devices/lab_pin.sym} 3610 -10860 0 1 {name=p2857 lab=_1758_/Y }
C {sky130_stdcells/o21ai_4.sym} 3530 -10860 0 0 {name=X_1758_ }
C {devices/lab_pin.sym} 3490 -10720 0 0 {name=p2858 lab=_1689_/A }
C {devices/lab_pin.sym} 3570 -10720 0 1 {name=p2859 lab=_1689_/Y }
C {sky130_stdcells/inv_2.sym} 3530 -10720 0 0 {name=X_1689_ }
C {devices/lab_pin.sym} 3490 -10600 0 0 {name=p2860 lab=clkbuf_2_3_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 3570 -10600 0 1 {name=p2861 lab=clkbuf_3_5_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 3530 -10600 0 0 {name=Xclkbuf_2_2_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 3490 -10480 0 0 {name=p2862 lab=_1612_/A }
C {devices/lab_pin.sym} 3570 -10480 0 1 {name=p2863 lab=_1612_/X }
C {sky130_stdcells/buf_2.sym} 3530 -10480 0 0 {name=X_1612_ }
C {devices/lab_pin.sym} 3440 -10360 0 0 {name=p2864 lab=_2590_/CLK }
C {devices/lab_pin.sym} 3440 -10340 0 0 {name=p2865 lab=_2592_/D }
C {devices/lab_pin.sym} 3620 -10360 0 1 {name=p2866 lab=_1662_/A }
C {sky130_stdcells/dfxtp_4.sym} 3530 -10350 0 0 {name=X_2592_ }
C {devices/lab_pin.sym} 3490 -10220 0 0 {name=p2867 lab=_1451_/X }
C {devices/lab_pin.sym} 3570 -10220 0 1 {name=p2868 lab=_2340_/C }
C {sky130_stdcells/buf_2.sym} 3530 -10220 0 0 {name=X_1474_ }
C {devices/lab_pin.sym} 3450 -10120 0 0 {name=p2869 lab=_1539_/Y }
C {devices/lab_pin.sym} 3450 -10080 0 0 {name=p2870 lab=_1540_/Y }
C {devices/lab_pin.sym} 3450 -10040 0 0 {name=p2871 lab=_1542_/X }
C {devices/lab_pin.sym} 3610 -10080 0 1 {name=p2872 lab=_2603_/D }
C {sky130_stdcells/a21oi_4.sym} 3530 -10080 0 0 {name=X_1543_ }
C {devices/lab_pin.sym} 3450 -9980 0 0 {name=p2873 lab=_2047_/A }
C {devices/lab_pin.sym} 3450 -9940 0 0 {name=p2874 lab=_2017_/B }
C {devices/lab_pin.sym} 3450 -9900 0 0 {name=p2875 lab=_2017_/C }
C {devices/lab_pin.sym} 3450 -9860 0 0 {name=p2876 lab=_2017_/D }
C {devices/lab_pin.sym} 3450 -9830 0 0 {name=p2877 lab=_2488_/Q }
C {devices/lab_pin.sym} 3610 -9900 0 1 {name=p2878 lab=_2028_/A }
C {sky130_stdcells/a41o_4.sym} 3530 -9900 0 0 {name=X_2026_ }
C {devices/lab_pin.sym} 3490 -9740 0 0 {name=p2879 lab=_1189_/Y }
C {devices/lab_pin.sym} 3570 -9740 0 1 {name=p2880 lab=_2096_/A }
C {sky130_stdcells/buf_2.sym} 3530 -9740 0 0 {name=X_1190_ }
C {devices/lab_pin.sym} 3440 -9620 0 0 {name=p2881 lab=_2638_/CLK }
C {devices/lab_pin.sym} 3440 -9600 0 0 {name=p2882 lab=_1264_/Y }
C {devices/lab_pin.sym} 3620 -9620 0 1 {name=p2883 lab=_1251_/A }
C {sky130_stdcells/dfxtp_4.sym} 3530 -9610 0 0 {name=X_2644_ }
C {devices/lab_pin.sym} 3470 -9490 0 0 {name=p2884 lab=_1443_/A }
C {devices/lab_pin.sym} 3470 -9450 0 0 {name=p2885 lab=_2390_/Q }
C {devices/lab_pin.sym} 3590 -9470 0 1 {name=p2886 lab=_1526_/Y }
C {sky130_stdcells/nor2_4.sym} 3530 -9470 0 0 {name=X_1526_ }
C {devices/lab_pin.sym} 3440 -9340 0 0 {name=p2887 lab=_2581_/CLK }
C {devices/lab_pin.sym} 3440 -9320 0 0 {name=p2888 lab=_2575_/D }
C {devices/lab_pin.sym} 3620 -9340 0 1 {name=p2889 lab=_2575_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -9330 0 0 {name=X_2575_ }
C {devices/lab_pin.sym} 3470 -9230 0 0 {name=p2890 lab=_1440_/B }
C {devices/lab_pin.sym} 3470 -9190 0 0 {name=p2891 lab=_1456_/X }
C {devices/lab_pin.sym} 3470 -9150 0 0 {name=p2892 lab=_1438_/D }
C {devices/lab_pin.sym} 3470 -9110 0 0 {name=p2893 lab=_1438_/A }
C {devices/lab_pin.sym} 3590 -9170 0 1 {name=p2894 lab=_1457_/X }
C {sky130_stdcells/and4_4.sym} 3530 -9170 0 0 {name=X_1457_ }
C {devices/lab_pin.sym} 3490 -9020 0 0 {name=p2895 lab=_1283_/X }
C {devices/lab_pin.sym} 3570 -9020 0 1 {name=p2896 lab=_1395_/A }
C {sky130_stdcells/buf_2.sym} 3530 -9020 0 0 {name=X_1388_ }
C {devices/lab_pin.sym} 3450 -8940 0 0 {name=p2897 lab=_2008_/Y }
C {devices/lab_pin.sym} 3450 -8900 0 0 {name=p2898 lab=_1984_/A }
C {devices/lab_pin.sym} 3450 -8860 0 0 {name=p2899 lab=_1999_/A }
C {devices/lab_pin.sym} 3450 -8820 0 0 {name=p2900 lab=_2011_/A }
C {devices/lab_pin.sym} 3450 -8790 0 0 {name=p2901 lab=_2492_/Q }
C {devices/lab_pin.sym} 3610 -8860 0 1 {name=p2902 lab=_2009_/X }
C {sky130_stdcells/a41o_4.sym} 3530 -8860 0 0 {name=X_2009_ }
C {sky130_stdcells/decap_3.sym} 3530 -8670 0 0 {name=XPHY_82 }
C {sky130_stdcells/decap_3.sym} 3530 -8490 0 0 {name=XPHY_71 }
C {sky130_stdcells/decap_3.sym} 3530 -8310 0 0 {name=XPHY_60 }
C {sky130_stdcells/decap_3.sym} 3530 -8130 0 0 {name=XPHY_93 }
C {devices/lab_pin.sym} 3490 -7980 0 0 {name=p2903 lab=_1243_/X }
C {devices/lab_pin.sym} 3570 -7980 0 1 {name=p2904 lab=_1316_/D }
C {sky130_stdcells/buf_2.sym} 3530 -7980 0 0 {name=X_1311_ }
C {devices/lab_pin.sym} 3490 -7860 0 0 {name=p2905 lab=MOSI_fromHost }
C {devices/lab_pin.sym} 3570 -7860 0 1 {name=p2906 lab=MOSI_toClient }
C {sky130_stdcells/buf_2.sym} 3530 -7860 0 0 {name=X_2360_ }
C {devices/lab_pin.sym} 3490 -7740 0 0 {name=p2907 lab=_2290_/Y }
C {devices/lab_pin.sym} 3570 -7740 0 1 {name=p2908 lab=_2291_/X }
C {sky130_stdcells/buf_2.sym} 3530 -7740 0 0 {name=X_2291_ }
C {devices/lab_pin.sym} 3470 -7650 0 0 {name=p2909 lab=_1335_/A }
C {devices/lab_pin.sym} 3470 -7610 0 0 {name=p2910 lab=_1242_/B }
C {devices/lab_pin.sym} 3470 -7570 0 0 {name=p2911 lab=_1242_/C }
C {devices/lab_pin.sym} 3470 -7530 0 0 {name=p2912 lab=_2629_/Q }
C {devices/lab_pin.sym} 3590 -7590 0 1 {name=p2913 lab=_1243_/A }
C {sky130_stdcells/and4_4.sym} 3530 -7590 0 0 {name=X_1242_ }
C {devices/lab_pin.sym} 3440 -7440 0 0 {name=p2914 lab=_2626_/CLK }
C {devices/lab_pin.sym} 3440 -7420 0 0 {name=p2915 lab=_2627_/D }
C {devices/lab_pin.sym} 3620 -7440 0 1 {name=p2916 lab=_1349_/A }
C {sky130_stdcells/dfxtp_4.sym} 3530 -7430 0 0 {name=X_2627_ }
C {devices/lab_pin.sym} 3440 -7300 0 0 {name=p2917 lab=_2470_/CLK }
C {devices/lab_pin.sym} 3440 -7280 0 0 {name=p2918 lab=_2025_/Y }
C {devices/lab_pin.sym} 3620 -7300 0 1 {name=p2919 lab=_1984_/A }
C {sky130_stdcells/dfxtp_4.sym} 3530 -7290 0 0 {name=X_2489_ }
C {devices/lab_pin.sym} 3440 -7160 0 0 {name=p2920 lab=_2562_/CLK }
C {devices/lab_pin.sym} 3440 -7140 0 0 {name=p2921 lab=_2558_/D }
C {devices/lab_pin.sym} 3620 -7160 0 1 {name=p2922 lab=_2558_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -7150 0 0 {name=X_2558_ }
C {devices/lab_pin.sym} 3450 -7040 0 0 {name=p2923 lab=_1508_/X }
C {devices/lab_pin.sym} 3450 -7000 0 0 {name=p2924 lab=_1448_/A }
C {devices/lab_pin.sym} 3450 -6960 0 0 {name=p2925 lab=_1505_/A }
C {devices/lab_pin.sym} 3610 -7000 0 1 {name=p2926 lab=_1509_/X }
C {sky130_stdcells/a21o_4.sym} 3530 -7000 0 0 {name=X_1509_ }
C {devices/lab_pin.sym} 3470 -6890 0 0 {name=p2927 lab=_2618_/Q }
C {devices/lab_pin.sym} 3470 -6850 0 0 {name=p2928 lab=_1860_/B }
C {devices/lab_pin.sym} 3470 -6810 0 0 {name=p2929 lab=_1661_/C }
C {devices/lab_pin.sym} 3470 -6770 0 0 {name=p2930 lab=_1661_/D }
C {devices/lab_pin.sym} 3590 -6830 0 1 {name=p2931 lab=_1860_/X }
C {sky130_stdcells/or4_4.sym} 3530 -6830 0 0 {name=X_1860_ }
C {devices/lab_pin.sym} 3450 -6700 0 0 {name=p2932 lab=_1788_/X }
C {devices/lab_pin.sym} 3450 -6660 0 0 {name=p2933 lab=_1420_/A }
C {devices/lab_pin.sym} 3450 -6620 0 0 {name=p2934 lab=_2326_/A }
C {devices/lab_pin.sym} 3610 -6660 0 1 {name=p2935 lab=_1791_/X }
C {sky130_stdcells/o21a_4.sym} 3530 -6660 0 0 {name=X_1791_ }
C {devices/lab_pin.sym} 3470 -6530 0 0 {name=p2936 lab=PLL_INPUT }
C {devices/lab_pin.sym} 3470 -6490 0 0 {name=p2937 lab=M1_CLK_SELECT }
C {devices/lab_pin.sym} 3590 -6510 0 1 {name=p2938 lab=_2343_/Y }
C {sky130_stdcells/nor2_4.sym} 3530 -6510 0 0 {name=X_2343_ }
C {devices/lab_pin.sym} 3440 -6380 0 0 {name=p2939 lab=_2410_/CLK }
C {devices/lab_pin.sym} 3440 -6360 0 0 {name=p2940 lab=_2412_/D }
C {devices/lab_pin.sym} 3620 -6380 0 1 {name=p2941 lab=_1927_/A }
C {sky130_stdcells/dfxtp_4.sym} 3530 -6370 0 0 {name=X_2412_ }
C {devices/lab_pin.sym} 3450 -6280 0 0 {name=p2942 lab=_2142_/Y }
C {devices/lab_pin.sym} 3450 -6240 0 0 {name=p2943 lab=_1649_/B }
C {devices/lab_pin.sym} 3450 -6200 0 0 {name=p2944 lab=_2270_/X }
C {devices/lab_pin.sym} 3450 -6160 0 0 {name=p2945 lab=_1947_/B }
C {devices/lab_pin.sym} 3450 -6120 0 0 {name=p2946 lab=_2263_/X }
C {devices/lab_pin.sym} 3610 -6200 0 1 {name=p2947 lab=_2420_/D }
C {sky130_stdcells/o32ai_4.sym} 3530 -6200 0 0 {name=X_2274_ }
C {devices/lab_pin.sym} 3490 -6040 0 0 {name=p2948 lab=_1225_/A }
C {devices/lab_pin.sym} 3570 -6040 0 1 {name=p2949 lab=_1225_/X }
C {sky130_stdcells/buf_2.sym} 3530 -6040 0 0 {name=X_1225_ }
C {devices/lab_pin.sym} 3490 -5920 0 0 {name=p2950 lab=_2478_/Q }
C {devices/lab_pin.sym} 3570 -5920 0 1 {name=p2951 lab=_1992_/B }
C {sky130_stdcells/inv_2.sym} 3530 -5920 0 0 {name=X_1989_ }
C {devices/lab_pin.sym} 3450 -5820 0 0 {name=p2952 lab=_1534_/X }
C {devices/lab_pin.sym} 3450 -5780 0 0 {name=p2953 lab=_2556_/Q }
C {devices/lab_pin.sym} 3450 -5740 0 0 {name=p2954 lab=_1614_/X }
C {devices/lab_pin.sym} 3610 -5780 0 1 {name=p2955 lab=_1843_/Y }
C {sky130_stdcells/o21ai_4.sym} 3530 -5780 0 0 {name=X_1843_ }
C {devices/lab_pin.sym} 3490 -5640 0 0 {name=p2956 lab=_1339_/X }
C {devices/lab_pin.sym} 3570 -5640 0 1 {name=p2957 lab=_1930_/A }
C {sky130_stdcells/buf_2.sym} 3530 -5640 0 0 {name=X_1912_ }
C {devices/lab_pin.sym} 3450 -5550 0 0 {name=p2958 lab=_1751_/B }
C {devices/lab_pin.sym} 3450 -5510 0 0 {name=p2959 lab=_2609_/Q }
C {devices/lab_pin.sym} 3450 -5470 0 0 {name=p2960 lab=_1487_/A }
C {devices/lab_pin.sym} 3450 -5430 0 0 {name=p2961 lab=_2158_/B }
C {devices/lab_pin.sym} 3610 -5490 0 1 {name=p2962 lab=_1777_/B }
C {sky130_stdcells/a22oi_4.sym} 3530 -5490 0 0 {name=X_1774_ }
C {devices/lab_pin.sym} 3450 -5360 0 0 {name=p2963 lab=_2437_/Q }
C {devices/lab_pin.sym} 3450 -5320 0 0 {name=p2964 lab=_1187_/A }
C {devices/lab_pin.sym} 3450 -5280 0 0 {name=p2965 lab=_1191_/X }
C {devices/lab_pin.sym} 3610 -5320 0 1 {name=p2966 lab=_1208_/Y }
C {sky130_stdcells/o21ai_4.sym} 3530 -5320 0 0 {name=X_1208_ }
C {devices/lab_pin.sym} 3470 -5210 0 0 {name=p2967 lab=_2326_/A }
C {devices/lab_pin.sym} 3470 -5170 0 0 {name=p2968 lab=_1423_/Y }
C {devices/lab_pin.sym} 3470 -5130 0 0 {name=p2969 lab=_1185_/A }
C {devices/lab_pin.sym} 3470 -5090 0 0 {name=p2970 lab=_1577_/X }
C {devices/lab_pin.sym} 3590 -5150 0 1 {name=p2971 lab=_2326_/Y }
C {sky130_stdcells/nand4_4.sym} 3530 -5150 0 0 {name=X_2326_ }
C {devices/lab_pin.sym} 3470 -5020 0 0 {name=p2972 lab=_2257_/A }
C {devices/lab_pin.sym} 3470 -4980 0 0 {name=p2973 lab=_1698_/A }
C {devices/lab_pin.sym} 3470 -4940 0 0 {name=p2974 lab=_1514_/X }
C {devices/lab_pin.sym} 3590 -4980 0 1 {name=p2975 lab=_2257_/Y }
C {sky130_stdcells/nand3_4.sym} 3530 -4980 0 0 {name=X_2257_ }
C {devices/lab_pin.sym} 3450 -4860 0 0 {name=p2976 lab=_2185_/Y }
C {devices/lab_pin.sym} 3450 -4820 0 0 {name=p2977 lab=_2186_/X }
C {devices/lab_pin.sym} 3450 -4780 0 0 {name=p2978 lab=_2187_/X }
C {devices/lab_pin.sym} 3610 -4820 0 1 {name=p2979 lab=_2188_/Y }
C {sky130_stdcells/a21oi_4.sym} 3530 -4820 0 0 {name=X_2188_ }
C {devices/lab_pin.sym} 3490 -4680 0 0 {name=p2980 lab=_1490_/A }
C {devices/lab_pin.sym} 3570 -4680 0 1 {name=p2981 lab=_1490_/Y }
C {sky130_stdcells/inv_2.sym} 3530 -4680 0 0 {name=X_1490_ }
C {devices/lab_pin.sym} 3450 -4600 0 0 {name=p2982 lab=_2041_/Y }
C {devices/lab_pin.sym} 3450 -4560 0 0 {name=p2983 lab=_1985_/A }
C {devices/lab_pin.sym} 3450 -4520 0 0 {name=p2984 lab=_2030_/X }
C {devices/lab_pin.sym} 3450 -4480 0 0 {name=p2985 lab=_2017_/B }
C {devices/lab_pin.sym} 3450 -4450 0 0 {name=p2986 lab=_2043_/D }
C {devices/lab_pin.sym} 3610 -4520 0 1 {name=p2987 lab=_2044_/A }
C {sky130_stdcells/a41o_4.sym} 3530 -4520 0 0 {name=X_2042_ }
C {devices/lab_pin.sym} 3470 -4370 0 0 {name=p2988 lab=_1870_/X }
C {devices/lab_pin.sym} 3470 -4330 0 0 {name=p2989 lab=_2098_/Y }
C {devices/lab_pin.sym} 3590 -4350 0 1 {name=p2990 lab=_2111_/Y }
C {sky130_stdcells/nand2_4.sym} 3530 -4350 0 0 {name=X_2111_ }
C {devices/lab_pin.sym} 3450 -4240 0 0 {name=p2991 lab=_2572_/Q }
C {devices/lab_pin.sym} 3450 -4200 0 0 {name=p2992 lab=_1808_/Y }
C {devices/lab_pin.sym} 3450 -4160 0 0 {name=p2993 lab=_1825_/X }
C {devices/lab_pin.sym} 3610 -4200 0 1 {name=p2994 lab=_2573_/D }
C {sky130_stdcells/o21a_4.sym} 3530 -4200 0 0 {name=X_1826_ }
C {devices/lab_pin.sym} 3450 -4080 0 0 {name=p2995 lab=_1612_/A }
C {devices/lab_pin.sym} 3450 -4040 0 0 {name=p2996 lab=_1360_/A }
C {devices/lab_pin.sym} 3450 -4000 0 0 {name=p2997 lab=_1656_/A }
C {devices/lab_pin.sym} 3610 -4040 0 1 {name=p2998 lab=_1757_/Y }
C {sky130_stdcells/a21oi_4.sym} 3530 -4040 0 0 {name=X_1757_ }
C {devices/lab_pin.sym} 3470 -3920 0 0 {name=p2999 lab=_1731_/B }
C {devices/lab_pin.sym} 3470 -3880 0 0 {name=p3000 lab=_1566_/X }
C {devices/lab_pin.sym} 3470 -3840 0 0 {name=p3001 lab=_2340_/B }
C {devices/lab_pin.sym} 3590 -3880 0 1 {name=p3002 lab=_1688_/Y }
C {sky130_stdcells/nor3_4.sym} 3530 -3880 0 0 {name=X_1688_ }
C {devices/lab_pin.sym} 3450 -3760 0 0 {name=p3003 lab=_2144_/Y }
C {devices/lab_pin.sym} 3450 -3720 0 0 {name=p3004 lab=_2292_/X }
C {devices/lab_pin.sym} 3450 -3680 0 0 {name=p3005 lab=_2308_/Y }
C {devices/lab_pin.sym} 3610 -3720 0 1 {name=p3006 lab=_2403_/D }
C {sky130_stdcells/o21ai_4.sym} 3530 -3720 0 0 {name=X_2309_ }
C {devices/lab_pin.sym} 3490 -3580 0 0 {name=p3007 lab=_1611_/A }
C {devices/lab_pin.sym} 3570 -3580 0 1 {name=p3008 lab=_1612_/A }
C {sky130_stdcells/buf_2.sym} 3530 -3580 0 0 {name=X_1611_ }
C {devices/lab_pin.sym} 3450 -3480 0 0 {name=p3009 lab=_1549_/A }
C {devices/lab_pin.sym} 3450 -3440 0 0 {name=p3010 lab=_1466_/Y }
C {devices/lab_pin.sym} 3450 -3400 0 0 {name=p3011 lab=_1500_/X }
C {devices/lab_pin.sym} 3610 -3440 0 1 {name=p3012 lab=_1542_/X }
C {sky130_stdcells/a21o_4.sym} 3530 -3440 0 0 {name=X_1542_ }
C {devices/lab_pin.sym} 3440 -3300 0 0 {name=p3013 lab=_2581_/CLK }
C {devices/lab_pin.sym} 3440 -3280 0 0 {name=p3014 lab=_2591_/D }
C {devices/lab_pin.sym} 3620 -3300 0 1 {name=p3015 lab=_2591_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -3290 0 0 {name=X_2591_ }
C {devices/lab_pin.sym} 3470 -3190 0 0 {name=p3016 lab=_1469_/Y }
C {devices/lab_pin.sym} 3470 -3150 0 0 {name=p3017 lab=_1473_/B }
C {devices/lab_pin.sym} 3470 -3110 0 0 {name=p3018 lab=_1473_/C }
C {devices/lab_pin.sym} 3470 -3070 0 0 {name=p3019 lab=_1438_/A }
C {devices/lab_pin.sym} 3590 -3130 0 1 {name=p3020 lab=_1473_/X }
C {sky130_stdcells/and4_4.sym} 3530 -3130 0 0 {name=X_1473_ }
C {devices/lab_pin.sym} 3450 -3000 0 0 {name=p3021 lab=_2002_/X }
C {devices/lab_pin.sym} 3450 -2960 0 0 {name=p3022 lab=_2013_/D }
C {devices/lab_pin.sym} 3450 -2920 0 0 {name=p3023 lab=_2024_/Y }
C {devices/lab_pin.sym} 3610 -2960 0 1 {name=p3024 lab=_2025_/Y }
C {sky130_stdcells/a21oi_4.sym} 3530 -2960 0 0 {name=X_2025_ }
C {devices/lab_pin.sym} 3490 -2820 0 0 {name=p3025 lab=_1808_/Y }
C {devices/lab_pin.sym} 3570 -2820 0 1 {name=p3026 lab=_1809_/X }
C {sky130_stdcells/buf_2.sym} 3530 -2820 0 0 {name=X_1809_ }
C {devices/lab_pin.sym} 3440 -2700 0 0 {name=p3027 lab=_2638_/CLK }
C {devices/lab_pin.sym} 3440 -2680 0 0 {name=p3028 lab=_2643_/D }
C {devices/lab_pin.sym} 3620 -2700 0 1 {name=p3029 lab=_1262_/C }
C {sky130_stdcells/dfxtp_4.sym} 3530 -2690 0 0 {name=X_2643_ }
C {devices/lab_pin.sym} 3440 -2560 0 0 {name=p3030 lab=_2581_/CLK }
C {devices/lab_pin.sym} 3440 -2540 0 0 {name=p3031 lab=_2574_/D }
C {devices/lab_pin.sym} 3620 -2560 0 1 {name=p3032 lab=_2574_/Q }
C {sky130_stdcells/dfxtp_4.sym} 3530 -2550 0 0 {name=X_2574_ }
C {devices/lab_pin.sym} 3490 -2420 0 0 {name=p3033 lab=_1387_/A }
C {devices/lab_pin.sym} 3570 -2420 0 1 {name=p3034 lab=_2622_/D }
C {sky130_stdcells/inv_2.sym} 3530 -2420 0 0 {name=X_1387_ }
C {devices/lab_pin.sym} 3490 -2300 0 0 {name=p3035 lab=_1438_/C }
C {devices/lab_pin.sym} 3570 -2300 0 1 {name=p3036 lab=_1456_/X }
C {sky130_stdcells/buf_2.sym} 3530 -2300 0 0 {name=X_1456_ }
C {devices/lab_pin.sym} 3450 -2200 0 0 {name=p3037 lab=_1473_/C }
C {devices/lab_pin.sym} 3450 -2160 0 0 {name=p3038 lab=_1469_/Y }
C {devices/lab_pin.sym} 3450 -2120 0 0 {name=p3039 lab=_1524_/Y }
C {devices/lab_pin.sym} 3610 -2160 0 1 {name=p3040 lab=_1525_/Y }
C {sky130_stdcells/o21ai_4.sym} 3530 -2160 0 0 {name=X_1525_ }
C {devices/lab_pin.sym} 3490 -2020 0 0 {name=p3041 lab=_2008_/A }
C {devices/lab_pin.sym} 3570 -2020 0 1 {name=p3042 lab=_2008_/Y }
C {sky130_stdcells/inv_2.sym} 3530 -2020 0 0 {name=X_2008_ }
C {sky130_stdcells/decap_3.sym} 3530 -1870 0 0 {name=XPHY_94 }
C {sky130_stdcells/decap_3.sym} 3530 -1690 0 0 {name=XPHY_83 }
C {sky130_stdcells/decap_3.sym} 3530 -1510 0 0 {name=XPHY_72 }
C {sky130_stdcells/decap_3.sym} 3530 -1330 0 0 {name=XPHY_61 }
C {sky130_stdcells/decap_3.sym} 3530 -1150 0 0 {name=XPHY_50 }
C {devices/lab_pin.sym} 3490 -1000 0 0 {name=p3043 lab=_1240_/Y }
C {devices/lab_pin.sym} 3570 -1000 0 1 {name=p3044 lab=_1241_/Y }
C {sky130_stdcells/inv_2.sym} 3530 -1000 0 0 {name=X_1241_ }
C {devices/lab_pin.sym} 3490 -880 0 0 {name=p3045 lab=_1309_/Y }
C {devices/lab_pin.sym} 3570 -880 0 1 {name=p3046 lab=_2636_/D }
C {sky130_stdcells/inv_2.sym} 3530 -880 0 0 {name=X_1310_ }
C {devices/lab_pin.sym} 9070 -21980 0 0 {name=p3047 lab=_2290_/A }
C {devices/lab_pin.sym} 9150 -21980 0 1 {name=p3048 lab=_2290_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -21980 0 0 {name=X_2290_ }
C {devices/lab_pin.sym} 9020 -21860 0 0 {name=p3049 lab=_2626_/CLK }
C {devices/lab_pin.sym} 9020 -21840 0 0 {name=p3050 lab=_2626_/D }
C {devices/lab_pin.sym} 9200 -21860 0 1 {name=p3051 lab=_1367_/A }
C {sky130_stdcells/dfxtp_4.sym} 9110 -21850 0 0 {name=X_2626_ }
C {devices/lab_pin.sym} 9020 -21720 0 0 {name=p3052 lab=_2557_/CLK }
C {devices/lab_pin.sym} 9020 -21700 0 0 {name=p3053 lab=_2557_/D }
C {devices/lab_pin.sym} 9200 -21720 0 1 {name=p3054 lab=_1701_/B }
C {sky130_stdcells/dfxtp_4.sym} 9110 -21710 0 0 {name=X_2557_ }
C {devices/lab_pin.sym} 9020 -21580 0 0 {name=p3055 lab=_2470_/CLK }
C {devices/lab_pin.sym} 9020 -21560 0 0 {name=p3056 lab=_2028_/X }
C {devices/lab_pin.sym} 9200 -21580 0 1 {name=p3057 lab=_2488_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -21570 0 0 {name=X_2488_ }
C {devices/lab_pin.sym} 9070 -21440 0 0 {name=p3058 lab=_1439_/A }
C {devices/lab_pin.sym} 9150 -21440 0 1 {name=p3059 lab=_1440_/D }
C {sky130_stdcells/buf_2.sym} 9110 -21440 0 0 {name=X_1439_ }
C {devices/lab_pin.sym} 9030 -21360 0 0 {name=p3060 lab=_1469_/Y }
C {devices/lab_pin.sym} 9030 -21320 0 0 {name=p3061 lab=_1505_/C }
C {devices/lab_pin.sym} 9030 -21280 0 0 {name=p3062 lab=_1438_/D }
C {devices/lab_pin.sym} 9030 -21240 0 0 {name=p3063 lab=_1473_/C }
C {devices/lab_pin.sym} 9030 -21210 0 0 {name=p3064 lab=_1451_/X }
C {devices/lab_pin.sym} 9190 -21280 0 1 {name=p3065 lab=_1508_/X }
C {sky130_stdcells/a41o_4.sym} 9110 -21280 0 0 {name=X_1508_ }
C {devices/lab_pin.sym} 9070 -21120 0 0 {name=p3066 lab=_1838_/A }
C {devices/lab_pin.sym} 9150 -21120 0 1 {name=p3067 lab=_2326_/A }
C {sky130_stdcells/buf_2.sym} 9110 -21120 0 0 {name=X_1790_ }
C {devices/lab_pin.sym} 9020 -21000 0 0 {name=p3068 lab=_2445_/CLK }
C {devices/lab_pin.sym} 9020 -20980 0 0 {name=p3069 lab=_2411_/D }
C {devices/lab_pin.sym} 9200 -21000 0 1 {name=p3070 lab=_2411_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -20990 0 0 {name=X_2411_ }
C {devices/lab_pin.sym} 9070 -20860 0 0 {name=p3071 lab=_1224_/A }
C {devices/lab_pin.sym} 9150 -20860 0 1 {name=p3072 lab=_1225_/A }
C {sky130_stdcells/inv_2.sym} 9110 -20860 0 0 {name=X_1224_ }
C {devices/lab_pin.sym} 9070 -20740 0 0 {name=p3073 lab=M1_CLK_IN }
C {devices/lab_pin.sym} 9150 -20740 0 1 {name=p3074 lab=_2342_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -20740 0 0 {name=X_2342_ }
C {devices/lab_pin.sym} 9030 -20660 0 0 {name=p3075 lab=_1503_/Y }
C {devices/lab_pin.sym} 9030 -20620 0 0 {name=p3076 lab=_1649_/B }
C {devices/lab_pin.sym} 9030 -20580 0 0 {name=p3077 lab=_2270_/X }
C {devices/lab_pin.sym} 9030 -20540 0 0 {name=p3078 lab=_1945_/B }
C {devices/lab_pin.sym} 9030 -20500 0 0 {name=p3079 lab=_2263_/X }
C {devices/lab_pin.sym} 9190 -20580 0 1 {name=p3080 lab=_2421_/D }
C {sky130_stdcells/o32ai_4.sym} 9110 -20580 0 0 {name=X_2273_ }
C {devices/lab_pin.sym} 9070 -20420 0 0 {name=p3081 lab=_2477_/Q }
C {devices/lab_pin.sym} 9150 -20420 0 1 {name=p3082 lab=_1992_/A }
C {sky130_stdcells/inv_2.sym} 9110 -20420 0 0 {name=X_1988_ }
C {devices/lab_pin.sym} 9070 -20300 0 0 {name=p3083 lab=clkbuf_2_3_0_m1_clk_local/A }
C {devices/lab_pin.sym} 9150 -20300 0 1 {name=p3084 lab=clkbuf_3_7_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 9110 -20300 0 0 {name=Xclkbuf_2_3_0_m1_clk_local }
C {devices/lab_pin.sym} 9020 -20180 0 0 {name=p3085 lab=_2388_/CLK }
C {devices/lab_pin.sym} 9020 -20160 0 0 {name=p3086 lab=_1493_/Y }
C {devices/lab_pin.sym} 9200 -20180 0 1 {name=p3087 lab=_2609_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -20170 0 0 {name=X_2609_ }
C {devices/lab_pin.sym} 9070 -20040 0 0 {name=p3088 lab=clkbuf_2_1_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 9150 -20040 0 1 {name=p3089 lab=clkbuf_4_5_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 9110 -20040 0 0 {name=Xclkbuf_3_2_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 9030 -19940 0 0 {name=p3090 lab=_1179_/X }
C {devices/lab_pin.sym} 9030 -19900 0 0 {name=p3091 lab=_1735_/D }
C {devices/lab_pin.sym} 9030 -19860 0 0 {name=p3092 lab=_1841_/Y }
C {devices/lab_pin.sym} 9190 -19900 0 1 {name=p3093 lab=_2569_/D }
C {sky130_stdcells/o21a_4.sym} 9110 -19900 0 0 {name=X_1842_ }
C {devices/lab_pin.sym} 9070 -19760 0 0 {name=p3094 lab=_1773_/A }
C {devices/lab_pin.sym} 9150 -19760 0 1 {name=p3095 lab=_2158_/B }
C {sky130_stdcells/inv_2.sym} 9110 -19760 0 0 {name=X_1773_ }
C {devices/lab_pin.sym} 9050 -19650 0 0 {name=p3096 lab=_1901_/X }
C {devices/lab_pin.sym} 9050 -19610 0 0 {name=p3097 lab=_1911_/B }
C {devices/lab_pin.sym} 9170 -19630 0 1 {name=p3098 lab=_1911_/Y }
C {sky130_stdcells/nor2_4.sym} 9110 -19630 0 0 {name=X_1911_ }
C {devices/lab_pin.sym} 9030 -19520 0 0 {name=p3099 lab=_2647_/Q }
C {devices/lab_pin.sym} 9030 -19480 0 0 {name=p3100 lab=_1179_/A }
C {devices/lab_pin.sym} 9030 -19440 0 0 {name=p3101 lab=_1206_/X }
C {devices/lab_pin.sym} 9190 -19480 0 1 {name=p3102 lab=_1207_/Y }
C {sky130_stdcells/o21ai_4.sym} 9110 -19480 0 0 {name=X_1207_ }
C {devices/lab_pin.sym} 9030 -19360 0 0 {name=p3103 lab=_1611_/A }
C {devices/lab_pin.sym} 9030 -19320 0 0 {name=p3104 lab=_1373_/B }
C {devices/lab_pin.sym} 9030 -19280 0 0 {name=p3105 lab=_1656_/A }
C {devices/lab_pin.sym} 9190 -19320 0 1 {name=p3106 lab=_2187_/X }
C {sky130_stdcells/a21o_4.sym} 9110 -19320 0 0 {name=X_2187_ }
C {devices/lab_pin.sym} 9030 -19200 0 0 {name=p3107 lab=_2324_/X }
C {devices/lab_pin.sym} 9030 -19160 0 0 {name=p3108 lab=_1688_/Y }
C {devices/lab_pin.sym} 9030 -19120 0 0 {name=p3109 lab=_1870_/X }
C {devices/lab_pin.sym} 9190 -19160 0 1 {name=p3110 lab=_2325_/X }
C {sky130_stdcells/o21a_4.sym} 9110 -19160 0 0 {name=X_2325_ }
C {devices/lab_pin.sym} 9030 -19060 0 0 {name=p3111 lab=_2244_/X }
C {devices/lab_pin.sym} 9030 -19020 0 0 {name=p3112 lab=_2255_/Y }
C {devices/lab_pin.sym} 9030 -18980 0 0 {name=p3113 lab=_2247_/X }
C {devices/lab_pin.sym} 9030 -18940 0 0 {name=p3114 lab=_1908_/Y }
C {devices/lab_pin.sym} 9030 -18900 0 0 {name=p3115 lab=_2249_/X }
C {devices/lab_pin.sym} 9190 -18980 0 1 {name=p3116 lab=_2429_/D }
C {sky130_stdcells/o32ai_4.sym} 9110 -18980 0 0 {name=X_2256_ }
C {devices/lab_pin.sym} 9070 -18820 0 0 {name=p3117 lab=_2040_/X }
C {devices/lab_pin.sym} 9150 -18820 0 1 {name=p3118 lab=_2041_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -18820 0 0 {name=X_2041_ }
C {devices/lab_pin.sym} 9050 -18710 0 0 {name=p3119 lab=_2108_/A }
C {devices/lab_pin.sym} 9050 -18670 0 0 {name=p3120 lab=MOSI_fromHost }
C {devices/lab_pin.sym} 9170 -18690 0 1 {name=p3121 lab=_2454_/D }
C {sky130_stdcells/and2_4.sym} 9110 -18690 0 0 {name=X_2110_ }
C {devices/lab_pin.sym} 9030 -18580 0 0 {name=p3122 lab=_1753_/X }
C {devices/lab_pin.sym} 9030 -18540 0 0 {name=p3123 lab=_1754_/X }
C {devices/lab_pin.sym} 9030 -18500 0 0 {name=p3124 lab=_1755_/Y }
C {devices/lab_pin.sym} 9190 -18540 0 1 {name=p3125 lab=_1756_/Y }
C {sky130_stdcells/a21oi_4.sym} 9110 -18540 0 0 {name=X_1756_ }
C {devices/lab_pin.sym} 9030 -18420 0 0 {name=p3126 lab=_2573_/Q }
C {devices/lab_pin.sym} 9030 -18380 0 0 {name=p3127 lab=_2461_/Q }
C {devices/lab_pin.sym} 9030 -18340 0 0 {name=p3128 lab=_2257_/A }
C {devices/lab_pin.sym} 9190 -18380 0 1 {name=p3129 lab=_1825_/X }
C {sky130_stdcells/o21a_4.sym} 9110 -18380 0 0 {name=X_1825_ }
C {devices/lab_pin.sym} 9070 -18240 0 0 {name=p3130 lab=clkbuf_4_7_0_m1_clk_local/A }
C {devices/lab_pin.sym} 9150 -18240 0 1 {name=p3131 lab=_2626_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9110 -18240 0 0 {name=Xclkbuf_4_6_0_m1_clk_local }
C {devices/lab_pin.sym} 9070 -18120 0 0 {name=p3132 lab=_1728_/C }
C {devices/lab_pin.sym} 9150 -18120 0 1 {name=p3133 lab=_2340_/B }
C {sky130_stdcells/inv_2.sym} 9110 -18120 0 0 {name=X_1687_ }
C {devices/lab_pin.sym} 9050 -18020 0 0 {name=p3134 lab=_2290_/Y }
C {devices/lab_pin.sym} 9050 -17980 0 0 {name=p3135 lab=_1602_/C }
C {devices/lab_pin.sym} 9050 -17940 0 0 {name=p3136 lab=_2089_/A }
C {devices/lab_pin.sym} 9170 -17980 0 1 {name=p3137 lab=_2308_/Y }
C {sky130_stdcells/nand3_4.sym} 9110 -17980 0 0 {name=X_2308_ }
C {devices/lab_pin.sym} 9070 -17840 0 0 {name=p3138 lab=_2239_/A }
C {devices/lab_pin.sym} 9150 -17840 0 1 {name=p3139 lab=_2239_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -17840 0 0 {name=X_2239_ }
C {devices/lab_pin.sym} 9020 -17720 0 0 {name=p3140 lab=_2590_/CLK }
C {devices/lab_pin.sym} 9020 -17700 0 0 {name=p3141 lab=_2590_/D }
C {devices/lab_pin.sym} 9200 -17720 0 1 {name=p3142 lab=_1762_/B }
C {sky130_stdcells/dfxtp_4.sym} 9110 -17710 0 0 {name=X_2590_ }
C {devices/lab_pin.sym} 9070 -17580 0 0 {name=p3143 lab=_1609_/X }
C {devices/lab_pin.sym} 9150 -17580 0 1 {name=p3144 lab=_1611_/A }
C {sky130_stdcells/buf_2.sym} 9110 -17580 0 0 {name=X_1610_ }
C {devices/lab_pin.sym} 9070 -17460 0 0 {name=p3145 lab=_1530_/Y }
C {devices/lab_pin.sym} 9150 -17460 0 1 {name=p3146 lab=_1549_/A }
C {sky130_stdcells/buf_2.sym} 9110 -17460 0 0 {name=X_1541_ }
C {devices/lab_pin.sym} 9070 -17340 0 0 {name=p3147 lab=_1471_/X }
C {devices/lab_pin.sym} 9150 -17340 0 1 {name=p3148 lab=_1473_/C }
C {sky130_stdcells/buf_2.sym} 9110 -17340 0 0 {name=X_1472_ }
C {devices/lab_pin.sym} 9030 -17240 0 0 {name=p3149 lab=_2002_/X }
C {devices/lab_pin.sym} 9030 -17200 0 0 {name=p3150 lab=_2013_/D }
C {devices/lab_pin.sym} 9030 -17160 0 0 {name=p3151 lab=_1346_/X }
C {devices/lab_pin.sym} 9190 -17200 0 1 {name=p3152 lab=_2024_/Y }
C {sky130_stdcells/o21ai_4.sym} 9110 -17200 0 0 {name=X_2024_ }
C {devices/lab_pin.sym} 9050 -17070 0 0 {name=p3153 lab=_1739_/A }
C {devices/lab_pin.sym} 9050 -17030 0 0 {name=p3154 lab=_1739_/B }
C {devices/lab_pin.sym} 9170 -17050 0 1 {name=p3155 lab=_1739_/Y }
C {sky130_stdcells/nor2_4.sym} 9110 -17050 0 0 {name=X_1739_ }
C {devices/lab_pin.sym} 9070 -16920 0 0 {name=p3156 lab=_2461_/Q }
C {devices/lab_pin.sym} 9150 -16920 0 1 {name=p3157 lab=_1808_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -16920 0 0 {name=X_1808_ }
C {devices/lab_pin.sym} 9020 -16800 0 0 {name=p3158 lab=_2641_/CLK }
C {devices/lab_pin.sym} 9020 -16780 0 0 {name=p3159 lab=_1279_/Y }
C {devices/lab_pin.sym} 9200 -16800 0 1 {name=p3160 lab=_1277_/A }
C {sky130_stdcells/dfxtp_4.sym} 9110 -16790 0 0 {name=X_2642_ }
C {devices/lab_pin.sym} 9020 -16660 0 0 {name=p3161 lab=_2581_/CLK }
C {devices/lab_pin.sym} 9020 -16640 0 0 {name=p3162 lab=_2573_/D }
C {devices/lab_pin.sym} 9200 -16660 0 1 {name=p3163 lab=_2573_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -16650 0 0 {name=X_2573_ }
C {devices/lab_pin.sym} 9030 -16560 0 0 {name=p3164 lab=_1473_/C }
C {devices/lab_pin.sym} 9030 -16520 0 0 {name=p3165 lab=_1429_/Y }
C {devices/lab_pin.sym} 9030 -16480 0 0 {name=p3166 lab=_1466_/A }
C {devices/lab_pin.sym} 9030 -16440 0 0 {name=p3167 lab=_2602_/Q }
C {devices/lab_pin.sym} 9030 -16410 0 0 {name=p3168 lab=_2340_/C }
C {devices/lab_pin.sym} 9190 -16480 0 1 {name=p3169 lab=_1524_/Y }
C {sky130_stdcells/a41oi_4.sym} 9110 -16480 0 0 {name=X_1524_ }
C {devices/lab_pin.sym} 9050 -16330 0 0 {name=p3170 lab=_1384_/X }
C {devices/lab_pin.sym} 9050 -16290 0 0 {name=p3171 lab=_1385_/Y }
C {devices/lab_pin.sym} 9170 -16310 0 1 {name=p3172 lab=_1387_/A }
C {sky130_stdcells/nand2_4.sym} 9110 -16310 0 0 {name=X_1386_ }
C {devices/lab_pin.sym} 9030 -16200 0 0 {name=p3173 lab=_1449_/Y }
C {devices/lab_pin.sym} 9030 -16160 0 0 {name=p3174 lab=_1453_/Y }
C {devices/lab_pin.sym} 9030 -16120 0 0 {name=p3175 lab=_1454_/X }
C {devices/lab_pin.sym} 9190 -16160 0 1 {name=p3176 lab=_1455_/Y }
C {sky130_stdcells/a21oi_4.sym} 9110 -16160 0 0 {name=X_1455_ }
C {devices/lab_pin.sym} 9070 -16020 0 0 {name=p3177 lab=_2006_/Y }
C {devices/lab_pin.sym} 9150 -16020 0 1 {name=p3178 lab=_2493_/D }
C {sky130_stdcells/inv_2.sym} 9110 -16020 0 0 {name=X_2007_ }
C {sky130_stdcells/decap_3.sym} 9110 -15870 0 0 {name=XPHY_95 }
C {sky130_stdcells/decap_3.sym} 9110 -15690 0 0 {name=XPHY_84 }
C {sky130_stdcells/decap_3.sym} 9110 -15510 0 0 {name=XPHY_73 }
C {sky130_stdcells/decap_3.sym} 9110 -15330 0 0 {name=XPHY_62 }
C {sky130_stdcells/decap_3.sym} 9110 -15150 0 0 {name=XPHY_51 }
C {sky130_stdcells/decap_3.sym} 9110 -14970 0 0 {name=XPHY_40 }
C {devices/lab_pin.sym} 9050 -14830 0 0 {name=p3179 lab=_2628_/Q }
C {devices/lab_pin.sym} 9050 -14790 0 0 {name=p3180 lab=_1349_/A }
C {devices/lab_pin.sym} 9170 -14810 0 1 {name=p3181 lab=_1240_/Y }
C {sky130_stdcells/nand2_4.sym} 9110 -14810 0 0 {name=X_1240_ }
C {devices/lab_pin.sym} 9020 -14680 0 0 {name=p3182 lab=_2470_/CLK }
C {devices/lab_pin.sym} 9020 -14660 0 0 {name=p3183 lab=_2625_/D }
C {devices/lab_pin.sym} 9200 -14680 0 1 {name=p3184 lab=_1360_/A }
C {sky130_stdcells/dfxtp_4.sym} 9110 -14670 0 0 {name=X_2625_ }
C {devices/lab_pin.sym} 9020 -14540 0 0 {name=p3185 lab=_2470_/CLK }
C {devices/lab_pin.sym} 9020 -14520 0 0 {name=p3186 lab=_2034_/X }
C {devices/lab_pin.sym} 9200 -14540 0 1 {name=p3187 lab=_2017_/C }
C {sky130_stdcells/dfxtp_4.sym} 9110 -14530 0 0 {name=X_2487_ }
C {devices/lab_pin.sym} 9020 -14400 0 0 {name=p3188 lab=_2562_/CLK }
C {devices/lab_pin.sym} 9020 -14380 0 0 {name=p3189 lab=_2556_/D }
C {devices/lab_pin.sym} 9200 -14400 0 1 {name=p3190 lab=_2556_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -14390 0 0 {name=X_2556_ }
C {devices/lab_pin.sym} 9050 -14270 0 0 {name=p3191 lab=_1506_/Y }
C {devices/lab_pin.sym} 9050 -14230 0 0 {name=p3192 lab=_1449_/B }
C {devices/lab_pin.sym} 9170 -14250 0 1 {name=p3193 lab=_1507_/Y }
C {sky130_stdcells/nand2_4.sym} 9110 -14250 0 0 {name=X_1507_ }
C {devices/lab_pin.sym} 9070 -14120 0 0 {name=p3194 lab=_1368_/Y }
C {devices/lab_pin.sym} 9150 -14120 0 1 {name=p3195 lab=_2626_/D }
C {sky130_stdcells/inv_2.sym} 9110 -14120 0 0 {name=X_1369_ }
C {devices/lab_pin.sym} 9050 -14030 0 0 {name=p3196 lab=_1438_/A }
C {devices/lab_pin.sym} 9050 -13990 0 0 {name=p3197 lab=_1438_/B }
C {devices/lab_pin.sym} 9050 -13950 0 0 {name=p3198 lab=_1438_/C }
C {devices/lab_pin.sym} 9050 -13910 0 0 {name=p3199 lab=_1438_/D }
C {devices/lab_pin.sym} 9170 -13970 0 1 {name=p3200 lab=_1439_/A }
C {sky130_stdcells/and4_4.sym} 9110 -13970 0 0 {name=X_1438_ }
C {devices/lab_pin.sym} 9070 -13820 0 0 {name=p3201 lab=EXT_RESET_N_fromHost }
C {devices/lab_pin.sym} 9150 -13820 0 1 {name=p3202 lab=_2341_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -13820 0 0 {name=X_2341_ }
C {devices/lab_pin.sym} 9020 -13700 0 0 {name=p3203 lab=_2410_/CLK }
C {devices/lab_pin.sym} 9020 -13680 0 0 {name=p3204 lab=_2410_/D }
C {devices/lab_pin.sym} 9200 -13700 0 1 {name=p3205 lab=_2410_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -13690 0 0 {name=X_2410_ }
C {devices/lab_pin.sym} 9030 -13580 0 0 {name=p3206 lab=_1216_/Y }
C {devices/lab_pin.sym} 9030 -13540 0 0 {name=p3207 lab=_1218_/Y }
C {devices/lab_pin.sym} 9030 -13500 0 0 {name=p3208 lab=_1222_/X }
C {devices/lab_pin.sym} 9190 -13540 0 1 {name=p3209 lab=_2645_/D }
C {sky130_stdcells/a21oi_4.sym} 9110 -13540 0 0 {name=X_1223_ }
C {devices/lab_pin.sym} 9030 -13440 0 0 {name=p3210 lab=_2136_/Y }
C {devices/lab_pin.sym} 9030 -13400 0 0 {name=p3211 lab=_2262_/X }
C {devices/lab_pin.sym} 9030 -13360 0 0 {name=p3212 lab=_2270_/X }
C {devices/lab_pin.sym} 9030 -13320 0 0 {name=p3213 lab=_1942_/B }
C {devices/lab_pin.sym} 9030 -13280 0 0 {name=p3214 lab=_2264_/X }
C {devices/lab_pin.sym} 9190 -13360 0 1 {name=p3215 lab=_2422_/D }
C {sky130_stdcells/o32ai_4.sym} 9110 -13360 0 0 {name=X_2272_ }
C {devices/lab_pin.sym} 9070 -13200 0 0 {name=p3216 lab=_1987_/A }
C {devices/lab_pin.sym} 9150 -13200 0 1 {name=p3217 lab=_1994_/C }
C {sky130_stdcells/inv_2.sym} 9110 -13200 0 0 {name=X_1987_ }
C {devices/lab_pin.sym} 9020 -13080 0 0 {name=p3218 lab=_2519_/CLK }
C {devices/lab_pin.sym} 9020 -13060 0 0 {name=p3219 lab=_2539_/D }
C {devices/lab_pin.sym} 9200 -13080 0 1 {name=p3220 lab=_2539_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -13070 0 0 {name=X_2539_ }
C {devices/lab_pin.sym} 9020 -12940 0 0 {name=p3221 lab=_2606_/CLK }
C {devices/lab_pin.sym} 9020 -12920 0 0 {name=p3222 lab=_1502_/Y }
C {devices/lab_pin.sym} 9200 -12940 0 1 {name=p3223 lab=_1436_/B }
C {sky130_stdcells/dfxtp_4.sym} 9110 -12930 0 0 {name=X_2608_ }
C {devices/lab_pin.sym} 9070 -12800 0 0 {name=p3224 lab=_2428_/Q }
C {devices/lab_pin.sym} 9150 -12800 0 1 {name=p3225 lab=_1911_/B }
C {sky130_stdcells/inv_2.sym} 9110 -12800 0 0 {name=X_1910_ }
C {devices/lab_pin.sym} 9070 -12680 0 0 {name=p3226 lab=_1841_/A }
C {devices/lab_pin.sym} 9150 -12680 0 1 {name=p3227 lab=_1841_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -12680 0 0 {name=X_1841_ }
C {devices/lab_pin.sym} 9030 -12590 0 0 {name=p3228 lab=_2609_/Q }
C {devices/lab_pin.sym} 9030 -12550 0 0 {name=p3229 lab=_1751_/B }
C {devices/lab_pin.sym} 9030 -12510 0 0 {name=p3230 lab=_1436_/C }
C {devices/lab_pin.sym} 9030 -12470 0 0 {name=p3231 lab=_1771_/Y }
C {devices/lab_pin.sym} 9190 -12530 0 1 {name=p3232 lab=_1777_/A }
C {sky130_stdcells/o22a_4.sym} 9110 -12530 0 0 {name=X_1772_ }
C {devices/lab_pin.sym} 9030 -12400 0 0 {name=p3233 lab=_1731_/B }
C {devices/lab_pin.sym} 9030 -12360 0 0 {name=p3234 lab=_1566_/X }
C {devices/lab_pin.sym} 9030 -12320 0 0 {name=p3235 lab=_1689_/A }
C {devices/lab_pin.sym} 9190 -12360 0 1 {name=p3236 lab=_2324_/X }
C {sky130_stdcells/o21a_4.sym} 9110 -12360 0 0 {name=X_2324_ }
C {devices/lab_pin.sym} 9070 -12220 0 0 {name=p3237 lab=clkbuf_3_7_0_m1_clk_local/X }
C {devices/lab_pin.sym} 9150 -12220 0 1 {name=p3238 lab=_2498_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9110 -12220 0 0 {name=Xclkbuf_4_14_0_m1_clk_local }
C {devices/lab_pin.sym} 9050 -12110 0 0 {name=p3239 lab=_1206_/A }
C {devices/lab_pin.sym} 9050 -12070 0 0 {name=p3240 lab=_1180_/Y }
C {devices/lab_pin.sym} 9170 -12090 0 1 {name=p3241 lab=_1206_/X }
C {sky130_stdcells/or2_4.sym} 9110 -12090 0 0 {name=X_1206_ }
C {devices/lab_pin.sym} 9030 -11980 0 0 {name=p3242 lab=_1335_/C }
C {devices/lab_pin.sym} 9030 -11940 0 0 {name=p3243 lab=_1646_/A }
C {devices/lab_pin.sym} 9030 -11900 0 0 {name=p3244 lab=_1741_/Y }
C {devices/lab_pin.sym} 9190 -11940 0 1 {name=p3245 lab=_2186_/X }
C {sky130_stdcells/o21a_4.sym} 9110 -11940 0 0 {name=X_2186_ }
C {devices/lab_pin.sym} 9050 -11820 0 0 {name=p3246 lab=_2257_/A }
C {devices/lab_pin.sym} 9050 -11780 0 0 {name=p3247 lab=_1698_/A }
C {devices/lab_pin.sym} 9050 -11740 0 0 {name=p3248 lab=_1503_/A }
C {devices/lab_pin.sym} 9170 -11780 0 1 {name=p3249 lab=_2255_/Y }
C {sky130_stdcells/nand3_4.sym} 9110 -11780 0 0 {name=X_2255_ }
C {devices/lab_pin.sym} 9070 -11640 0 0 {name=p3250 lab=_1994_/D }
C {devices/lab_pin.sym} 9150 -11640 0 1 {name=p3251 lab=_2040_/X }
C {sky130_stdcells/buf_2.sym} 9110 -11640 0 0 {name=X_2040_ }
C {devices/lab_pin.sym} 9030 -11540 0 0 {name=p3252 lab=_1280_/Y }
C {devices/lab_pin.sym} 9030 -11500 0 0 {name=p3253 lab=_1614_/X }
C {devices/lab_pin.sym} 9030 -11460 0 0 {name=p3254 lab=_1646_/X }
C {devices/lab_pin.sym} 9190 -11500 0 1 {name=p3255 lab=_1755_/Y }
C {sky130_stdcells/o21ai_4.sym} 9110 -11500 0 0 {name=X_1755_ }
C {devices/lab_pin.sym} 9030 -11380 0 0 {name=p3256 lab=_1678_/Y }
C {devices/lab_pin.sym} 9030 -11340 0 0 {name=p3257 lab=_1682_/Y }
C {devices/lab_pin.sym} 9030 -11300 0 0 {name=p3258 lab=_1685_/X }
C {devices/lab_pin.sym} 9190 -11340 0 1 {name=p3259 lab=_1686_/Y }
C {sky130_stdcells/a21oi_4.sym} 9110 -11340 0 0 {name=X_1686_ }
C {devices/lab_pin.sym} 9070 -11200 0 0 {name=p3260 lab=_1838_/A }
C {devices/lab_pin.sym} 9150 -11200 0 1 {name=p3261 lab=_2257_/A }
C {sky130_stdcells/buf_2.sym} 9110 -11200 0 0 {name=X_1824_ }
C {devices/lab_pin.sym} 9030 -11100 0 0 {name=p3262 lab=_2142_/Y }
C {devices/lab_pin.sym} 9030 -11060 0 0 {name=p3263 lab=_2292_/X }
C {devices/lab_pin.sym} 9030 -11020 0 0 {name=p3264 lab=_2306_/Y }
C {devices/lab_pin.sym} 9190 -11060 0 1 {name=p3265 lab=_2307_/Y }
C {sky130_stdcells/o21ai_4.sym} 9110 -11060 0 0 {name=X_2307_ }
C {devices/lab_pin.sym} 9050 -10950 0 0 {name=p3266 lab=_1609_/B }
C {devices/lab_pin.sym} 9050 -10910 0 0 {name=p3267 lab=_1189_/Y }
C {devices/lab_pin.sym} 9050 -10870 0 0 {name=p3268 lab=_1583_/X }
C {devices/lab_pin.sym} 9050 -10830 0 0 {name=p3269 lab=_1696_/A }
C {devices/lab_pin.sym} 9170 -10890 0 1 {name=p3270 lab=_2239_/A }
C {sky130_stdcells/and4_4.sym} 9110 -10890 0 0 {name=X_2238_ }
C {devices/lab_pin.sym} 9030 -10770 0 0 {name=p3271 lab=_2546_/Q }
C {devices/lab_pin.sym} 9030 -10730 0 0 {name=p3272 lab=_1739_/B }
C {devices/lab_pin.sym} 9030 -10690 0 0 {name=p3273 lab=_2167_/Y }
C {devices/lab_pin.sym} 9030 -10650 0 0 {name=p3274 lab=_2168_/Y }
C {devices/lab_pin.sym} 9190 -10710 0 1 {name=p3275 lab=_2169_/Y }
C {sky130_stdcells/a22oi_4.sym} 9110 -10710 0 0 {name=X_2169_ }
C {devices/lab_pin.sym} 9030 -10580 0 0 {name=p3276 lab=_2266_/A }
C {devices/lab_pin.sym} 9030 -10540 0 0 {name=p3277 lab=_1527_/Y }
C {devices/lab_pin.sym} 9030 -10500 0 0 {name=p3278 lab=_1556_/A }
C {devices/lab_pin.sym} 9190 -10540 0 1 {name=p3279 lab=_1540_/Y }
C {sky130_stdcells/a21oi_4.sym} 9110 -10540 0 0 {name=X_1540_ }
C {devices/lab_pin.sym} 9070 -10400 0 0 {name=p3280 lab=_2604_/Q }
C {devices/lab_pin.sym} 9150 -10400 0 1 {name=p3281 lab=_1471_/X }
C {sky130_stdcells/buf_2.sym} 9110 -10400 0 0 {name=X_1471_ }
C {devices/lab_pin.sym} 9070 -10280 0 0 {name=p3282 lab=_2022_/Y }
C {devices/lab_pin.sym} 9150 -10280 0 1 {name=p3283 lab=_2490_/D }
C {sky130_stdcells/inv_2.sym} 9110 -10280 0 0 {name=X_2023_ }
C {devices/lab_pin.sym} 9030 -10180 0 0 {name=p3284 lab=_1786_/Y }
C {devices/lab_pin.sym} 9030 -10140 0 0 {name=p3285 lab=_2572_/Q }
C {devices/lab_pin.sym} 9030 -10100 0 0 {name=p3286 lab=_1806_/X }
C {devices/lab_pin.sym} 9190 -10140 0 1 {name=p3287 lab=_1807_/X }
C {sky130_stdcells/o21a_4.sym} 9110 -10140 0 0 {name=X_1807_ }
C {devices/lab_pin.sym} 9050 -10010 0 0 {name=p3288 lab=_1831_/A }
C {devices/lab_pin.sym} 9050 -9970 0 0 {name=p3289 lab=_1738_/B }
C {devices/lab_pin.sym} 9170 -9990 0 1 {name=p3290 lab=_2591_/D }
C {sky130_stdcells/nor2_4.sym} 9110 -9990 0 0 {name=X_1738_ }
C {devices/lab_pin.sym} 9050 -9880 0 0 {name=p3291 lab=_1579_/X }
C {devices/lab_pin.sym} 9050 -9840 0 0 {name=p3292 lab=_1669_/B }
C {devices/lab_pin.sym} 9050 -9800 0 0 {name=p3293 lab=_1590_/B }
C {devices/lab_pin.sym} 9170 -9840 0 1 {name=p3294 lab=_1669_/Y }
C {sky130_stdcells/nor3_4.sym} 9110 -9840 0 0 {name=X_1669_ }
C {devices/lab_pin.sym} 9070 -9700 0 0 {name=p3295 lab=_1222_/A }
C {devices/lab_pin.sym} 9150 -9700 0 1 {name=p3296 lab=_1454_/X }
C {sky130_stdcells/buf_2.sym} 9110 -9700 0 0 {name=X_1454_ }
C {devices/lab_pin.sym} 9020 -9580 0 0 {name=p3297 lab=_2641_/CLK }
C {devices/lab_pin.sym} 9020 -9560 0 0 {name=p3298 lab=_1282_/X }
C {devices/lab_pin.sym} 9200 -9580 0 1 {name=p3299 lab=_2641_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -9570 0 0 {name=X_2641_ }
C {devices/lab_pin.sym} 9020 -9440 0 0 {name=p3300 lab=_2581_/CLK }
C {devices/lab_pin.sym} 9020 -9420 0 0 {name=p3301 lab=_2572_/D }
C {devices/lab_pin.sym} 9200 -9440 0 1 {name=p3302 lab=_2572_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -9430 0 0 {name=X_2572_ }
C {devices/lab_pin.sym} 9030 -9320 0 0 {name=p3303 lab=_1519_/Y }
C {devices/lab_pin.sym} 9030 -9280 0 0 {name=p3304 lab=_1521_/Y }
C {devices/lab_pin.sym} 9030 -9240 0 0 {name=p3305 lab=_1522_/Y }
C {devices/lab_pin.sym} 9190 -9280 0 1 {name=p3306 lab=_2605_/D }
C {sky130_stdcells/a21oi_4.sym} 9110 -9280 0 0 {name=X_1523_ }
C {devices/lab_pin.sym} 9050 -9170 0 0 {name=p3307 lab=_1385_/A }
C {devices/lab_pin.sym} 9050 -9130 0 0 {name=p3308 lab=_1379_/A }
C {devices/lab_pin.sym} 9050 -9090 0 0 {name=p3309 lab=_2621_/Q }
C {devices/lab_pin.sym} 9050 -9050 0 0 {name=p3310 lab=_1385_/D }
C {devices/lab_pin.sym} 9170 -9110 0 1 {name=p3311 lab=_1385_/Y }
C {sky130_stdcells/nand4_4.sym} 9110 -9110 0 0 {name=X_1385_ }
C {devices/lab_pin.sym} 9050 -8980 0 0 {name=p3312 lab=_2001_/Y }
C {devices/lab_pin.sym} 9050 -8940 0 0 {name=p3313 lab=_2006_/B }
C {devices/lab_pin.sym} 9050 -8900 0 0 {name=p3314 lab=_2005_/Y }
C {devices/lab_pin.sym} 9170 -8940 0 1 {name=p3315 lab=_2006_/Y }
C {sky130_stdcells/nand3_4.sym} 9110 -8940 0 0 {name=X_2006_ }
C {sky130_stdcells/decap_3.sym} 9110 -8770 0 0 {name=XPHY_30 }
C {sky130_stdcells/decap_3.sym} 9110 -8590 0 0 {name=XPHY_96 }
C {sky130_stdcells/decap_3.sym} 9110 -8410 0 0 {name=XPHY_85 }
C {sky130_stdcells/decap_3.sym} 9110 -8230 0 0 {name=XPHY_74 }
C {sky130_stdcells/decap_3.sym} 9110 -8050 0 0 {name=XPHY_63 }
C {sky130_stdcells/decap_3.sym} 9110 -7870 0 0 {name=XPHY_52 }
C {sky130_stdcells/decap_3.sym} 9110 -7690 0 0 {name=XPHY_41 }
C {devices/lab_pin.sym} 9020 -7540 0 0 {name=p3316 lab=_2370_/CLK }
C {devices/lab_pin.sym} 9020 -7520 0 0 {name=p3317 lab=_2624_/D }
C {devices/lab_pin.sym} 9200 -7540 0 1 {name=p3318 lab=_1236_/A }
C {sky130_stdcells/dfxtp_4.sym} 9110 -7530 0 0 {name=X_2624_ }
C {devices/lab_pin.sym} 9020 -7400 0 0 {name=p3319 lab=_2483_/CLK }
C {devices/lab_pin.sym} 9020 -7380 0 0 {name=p3320 lab=_2486_/D }
C {devices/lab_pin.sym} 9200 -7400 0 1 {name=p3321 lab=_2037_/D }
C {sky130_stdcells/dfxtp_4.sym} 9110 -7390 0 0 {name=X_2486_ }
C {devices/lab_pin.sym} 9020 -7260 0 0 {name=p3322 lab=_2562_/CLK }
C {devices/lab_pin.sym} 9020 -7240 0 0 {name=p3323 lab=_1885_/X }
C {devices/lab_pin.sym} 9200 -7260 0 1 {name=p3324 lab=_2555_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -7250 0 0 {name=X_2555_ }
C {devices/lab_pin.sym} 9070 -7120 0 0 {name=p3325 lab=clkbuf_4_3_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 9150 -7120 0 1 {name=p3326 lab=_2445_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9110 -7120 0 0 {name=Xclkbuf_4_2_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 9070 -7000 0 0 {name=p3327 lab=_1483_/B }
C {devices/lab_pin.sym} 9150 -7000 0 1 {name=p3328 lab=_1438_/D }
C {sky130_stdcells/buf_2.sym} 9110 -7000 0 0 {name=X_1437_ }
C {devices/lab_pin.sym} 9030 -6900 0 0 {name=p3329 lab=_1503_/Y }
C {devices/lab_pin.sym} 9030 -6860 0 0 {name=p3330 lab=_1445_/D }
C {devices/lab_pin.sym} 9030 -6820 0 0 {name=p3331 lab=_1505_/Y }
C {devices/lab_pin.sym} 9190 -6860 0 1 {name=p3332 lab=_1506_/Y }
C {sky130_stdcells/o21ai_4.sym} 9110 -6860 0 0 {name=X_1506_ }
C {devices/lab_pin.sym} 9050 -6730 0 0 {name=p3333 lab=_1362_/X }
C {devices/lab_pin.sym} 9050 -6690 0 0 {name=p3334 lab=_1367_/Y }
C {devices/lab_pin.sym} 9170 -6710 0 1 {name=p3335 lab=_1368_/Y }
C {sky130_stdcells/nand2_4.sym} 9110 -6710 0 0 {name=X_1368_ }
C {devices/lab_pin.sym} 9070 -6580 0 0 {name=p3336 lab=_1299_/A }
C {devices/lab_pin.sym} 9150 -6580 0 1 {name=p3337 lab=_1300_/B }
C {sky130_stdcells/inv_2.sym} 9110 -6580 0 0 {name=X_1299_ }
C {devices/lab_pin.sym} 9070 -6460 0 0 {name=p3338 lab=clkbuf_3_7_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 9150 -6460 0 1 {name=p3339 lab=clkbuf_3_7_0_addressalyzerBlock.SPI_CLK/X }
C {sky130_stdcells/clkbuf_1.sym} 9110 -6460 0 0 {name=Xclkbuf_3_7_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 9050 -6360 0 0 {name=p3340 lab=_2102_/A }
C {devices/lab_pin.sym} 9050 -6320 0 0 {name=p3341 lab=_2340_/B }
C {devices/lab_pin.sym} 9050 -6280 0 0 {name=p3342 lab=_2340_/C }
C {devices/lab_pin.sym} 9170 -6320 0 1 {name=p3343 lab=_2393_/D }
C {sky130_stdcells/nor3_4.sym} 9110 -6320 0 0 {name=X_2340_ }
C {devices/lab_pin.sym} 9030 -6220 0 0 {name=p3344 lab=_1490_/Y }
C {devices/lab_pin.sym} 9030 -6180 0 0 {name=p3345 lab=_2262_/X }
C {devices/lab_pin.sym} 9030 -6140 0 0 {name=p3346 lab=_2270_/X }
C {devices/lab_pin.sym} 9030 -6100 0 0 {name=p3347 lab=_1746_/Y }
C {devices/lab_pin.sym} 9030 -6060 0 0 {name=p3348 lab=_2264_/X }
C {devices/lab_pin.sym} 9190 -6140 0 1 {name=p3349 lab=_2271_/Y }
C {sky130_stdcells/o32ai_4.sym} 9110 -6140 0 0 {name=X_2271_ }
C {devices/lab_pin.sym} 9070 -5980 0 0 {name=p3350 lab=_1222_/A }
C {devices/lab_pin.sym} 9150 -5980 0 1 {name=p3351 lab=_1222_/X }
C {sky130_stdcells/buf_2.sym} 9110 -5980 0 0 {name=X_1222_ }
C {devices/lab_pin.sym} 9070 -5860 0 0 {name=p3352 lab=_2030_/A }
C {devices/lab_pin.sym} 9150 -5860 0 1 {name=p3353 lab=_1986_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -5860 0 0 {name=X_1986_ }
C {devices/lab_pin.sym} 9020 -5740 0 0 {name=p3354 lab=_2606_/CLK }
C {devices/lab_pin.sym} 9020 -5720 0 0 {name=p3355 lab=_2607_/D }
C {devices/lab_pin.sym} 9200 -5740 0 1 {name=p3356 lab=_1436_/C }
C {sky130_stdcells/dfxtp_4.sym} 9110 -5730 0 0 {name=X_2607_ }
C {devices/lab_pin.sym} 9020 -5600 0 0 {name=p3357 lab=_2641_/CLK }
C {devices/lab_pin.sym} 9020 -5580 0 0 {name=p3358 lab=_2090_/Y }
C {devices/lab_pin.sym} 9200 -5600 0 1 {name=p3359 lab=_2088_/B }
C {sky130_stdcells/dfxtp_4.sym} 9110 -5590 0 0 {name=X_2469_ }
C {devices/lab_pin.sym} 9020 -5460 0 0 {name=p3360 lab=_2519_/CLK }
C {devices/lab_pin.sym} 9020 -5440 0 0 {name=p3361 lab=_1911_/Y }
C {devices/lab_pin.sym} 9200 -5460 0 1 {name=p3362 lab=_2538_/Q }
C {sky130_stdcells/dfxtp_4.sym} 9110 -5450 0 0 {name=X_2538_ }
C {devices/lab_pin.sym} 9050 -5340 0 0 {name=p3363 lab=_1834_/A }
C {devices/lab_pin.sym} 9050 -5300 0 0 {name=p3364 lab=_1840_/B }
C {devices/lab_pin.sym} 9050 -5260 0 0 {name=p3365 lab=_1840_/C }
C {devices/lab_pin.sym} 9170 -5300 0 1 {name=p3366 lab=_1841_/A }
C {sky130_stdcells/nand3_4.sym} 9110 -5300 0 0 {name=X_1840_ }
C {devices/lab_pin.sym} 9070 -5160 0 0 {name=p3367 lab=_2397_/Q }
C {devices/lab_pin.sym} 9150 -5160 0 1 {name=p3368 lab=_1771_/Y }
C {sky130_stdcells/inv_2.sym} 9110 -5160 0 0 {name=X_1771_ }
C {devices/lab_pin.sym} 9030 -5060 0 0 {name=p3369 lab=_2322_/Y }
C {devices/lab_pin.sym} 9030 -5020 0 0 {name=p3370 lab=_1697_/Y }
C {devices/lab_pin.sym} 9030 -4980 0 0 {name=p3371 lab=_1781_/X }
C {devices/lab_pin.sym} 9190 -5020 0 1 {name=p3372 lab=_2392_/D }
C {sky130_stdcells/a21oi_4.sym} 9110 -5020 0 0 {name=X_2323_ }
C {devices/lab_pin.sym} 9030 -4920 0 0 {name=p3373 lab=_2244_/X }
C {devices/lab_pin.sym} 9030 -4880 0 0 {name=p3374 lab=_2253_/Y }
C {devices/lab_pin.sym} 9030 -4840 0 0 {name=p3375 lab=_2247_/X }
C {devices/lab_pin.sym} 9030 -4800 0 0 {name=p3376 lab=_1906_/Y }
C {devices/lab_pin.sym} 9030 -4760 0 0 {name=p3377 lab=_2249_/X }
C {devices/lab_pin.sym} 9190 -4840 0 1 {name=p3378 lab=_2254_/Y }
C {sky130_stdcells/o32ai_4.sym} 9110 -4840 0 0 {name=X_2254_ }
C {devices/lab_pin.sym} 9030 -4700 0 0 {name=p3379 lab=_1203_/Y }
C {devices/lab_pin.sym} 9030 -4660 0 0 {name=p3380 lab=_1187_/X }
C {devices/lab_pin.sym} 9030 -4620 0 0 {name=p3381 lab=_1204_/Y }
C {devices/lab_pin.sym} 9190 -4660 0 1 {name=p3382 lab=_1205_/Y }
C {sky130_stdcells/a21oi_4.sym} 9110 -4660 0 0 {name=X_1205_ }
C {devices/lab_pin.sym} 9030 -4540 0 0 {name=p3383 lab=_2173_/Y }
C {devices/lab_pin.sym} 9030 -4500 0 0 {name=p3384 lab=_2183_/Y }
C {devices/lab_pin.sym} 9030 -4460 0 0 {name=p3385 lab=_2184_/Y }
C {devices/lab_pin.sym} 9190 -4500 0 1 {name=p3386 lab=_2185_/Y }
C {sky130_stdcells/o21ai_4.sym} 9110 -4500 0 0 {name=X_2185_ }
C {devices/lab_pin.sym} 9050 -4370 0 0 {name=p3387 lab=_1969_/A }
C {devices/lab_pin.sym} 9050 -4330 0 0 {name=p3388 lab=_2505_/Q }
C {devices/lab_pin.sym} 9170 -4350 0 1 {name=p3389 lab=_1969_/X }
C {sky130_stdcells/and2_4.sym} 9110 -4350 0 0 {name=X_1969_ }
C {devices/lab_pin.sym} 9030 -4240 0 0 {name=p3390 lab=_2573_/Q }
C {devices/lab_pin.sym} 9030 -4200 0 0 {name=p3391 lab=_1808_/Y }
C {devices/lab_pin.sym} 9030 -4160 0 0 {name=p3392 lab=_1822_/X }
C {devices/lab_pin.sym} 9190 -4200 0 1 {name=p3393 lab=_2574_/D }
C {sky130_stdcells/o21a_4.sym} 9110 -4200 0 0 {name=X_1823_ }
C {devices/lab_pin.sym} 9030 -4080 0 0 {name=p3394 lab=_1534_/X }
C {devices/lab_pin.sym} 9030 -4040 0 0 {name=p3395 lab=_2555_/Q }
C {devices/lab_pin.sym} 9030 -4000 0 0 {name=p3396 lab=_1614_/X }
C {devices/lab_pin.sym} 9190 -4040 0 1 {name=p3397 lab=_1754_/X }
C {sky130_stdcells/o21a_4.sym} 9110 -4040 0 0 {name=X_1754_ }
C {devices/lab_pin.sym} 9030 -3920 0 0 {name=p3398 lab=_1681_/X }
C {devices/lab_pin.sym} 9030 -3880 0 0 {name=p3399 lab=_1684_/Y }
C {devices/lab_pin.sym} 9030 -3840 0 0 {name=p3400 lab=_1500_/X }
C {devices/lab_pin.sym} 9190 -3880 0 1 {name=p3401 lab=_1685_/X }
C {sky130_stdcells/a21o_4.sym} 9110 -3880 0 0 {name=X_1685_ }
C {devices/lab_pin.sym} 9030 -3760 0 0 {name=p3402 lab=_2235_/Y }
C {devices/lab_pin.sym} 9030 -3720 0 0 {name=p3403 lab=_1662_/A }
C {devices/lab_pin.sym} 9030 -3680 0 0 {name=p3404 lab=_2236_/Y }
C {devices/lab_pin.sym} 9190 -3720 0 1 {name=p3405 lab=_2237_/Y }
C {sky130_stdcells/a21oi_4.sym} 9110 -3720 0 0 {name=X_2237_ }
C {devices/lab_pin.sym} 9050 -3600 0 0 {name=p3406 lab=_2304_/A }
C {devices/lab_pin.sym} 9050 -3560 0 0 {name=p3407 lab=_1602_/C }
C {devices/lab_pin.sym} 9050 -3520 0 0 {name=p3408 lab=_2404_/Q }
C {devices/lab_pin.sym} 9170 -3560 0 1 {name=p3409 lab=_2306_/Y }
C {sky130_stdcells/nand3_4.sym} 9110 -3560 0 0 {name=X_2306_ }
C {devices/lab_pin.sym} 9050 -3430 0 0 {name=p3410 lab=_1673_/C }
C {devices/lab_pin.sym} 9050 -3390 0 0 {name=p3411 lab=_1672_/A }
C {devices/lab_pin.sym} 9170 -3410 0 1 {name=p3412 lab=_2168_/Y }
C {sky130_stdcells/nor2_4.sym} 9110 -3410 0 0 {name=X_2168_ }
C {devices/lab_pin.sym} 9050 -3300 0 0 {name=p3413 lab=_2104_/A }
C {devices/lab_pin.sym} 9050 -3260 0 0 {name=p3414 lab=_2098_/Y }
C {devices/lab_pin.sym} 9050 -3220 0 0 {name=p3415 lab=_2099_/C }
C {devices/lab_pin.sym} 9170 -3260 0 1 {name=p3416 lab=_2099_/X }
C {sky130_stdcells/and3_4.sym} 9110 -3260 0 0 {name=X_2099_ }
C {devices/lab_pin.sym} 9070 -3120 0 0 {name=p3417 lab=_1438_/D }
C {devices/lab_pin.sym} 9150 -3120 0 1 {name=p3418 lab=_1473_/B }
C {sky130_stdcells/buf_2.sym} 9110 -3120 0 0 {name=X_1470_ }
C {devices/lab_pin.sym} 9050 -3020 0 0 {name=p3419 lab=_2022_/A }
C {devices/lab_pin.sym} 9050 -2980 0 0 {name=p3420 lab=_2006_/B }
C {devices/lab_pin.sym} 9050 -2940 0 0 {name=p3421 lab=_2021_/Y }
C {devices/lab_pin.sym} 9170 -2980 0 1 {name=p3422 lab=_2022_/Y }
C {sky130_stdcells/nand3_4.sym} 9110 -2980 0 0 {name=X_2022_ }
C {devices/lab_pin.sym} 9030 -2860 0 0 {name=p3423 lab=_2591_/Q }
C {devices/lab_pin.sym} 9030 -2820 0 0 {name=p3424 lab=_1520_/X }
C {devices/lab_pin.sym} 9030 -2780 0 0 {name=p3425 lab=_1799_/X }
C {devices/lab_pin.sym} 9190 -2820 0 1 {name=p3426 lab=_1806_/X }
C {sky130_stdcells/o21a_4.sym} 9110 -2820 0 0 {name=X_1806_ }
C {devices/lab_pin.sym} 9070 -2680 0 0 {name=p3427 lab=_1831_/B }
C {devices/lab_pin.sym} 9150 -2680 0 1 {name=p3428 lab=_1738_/B }
C {sky130_stdcells/inv_2.sym} 9110 -2680 0 0 {name=X_1737_ }
C {devices/lab_pin.sym} 9070 -2560 0 0 {name=p3429 lab=_1667_/X }
C {devices/lab_pin.sym} 9150 -2560 0 1 {name=p3430 lab=_1673_/C }
C {sky130_stdcells/buf_2.sym} 9110 -2560 0 0 {name=X_1668_ }
C {devices/lab_pin.sym} 9030 -2470 0 0 {name=p3431 lab=_1600_/B }
C {devices/lab_pin.sym} 9030 -2430 0 0 {name=p3432 lab=_1488_/X }
C {devices/lab_pin.sym} 9030 -2390 0 0 {name=p3433 lab=_1598_/X }
C {devices/lab_pin.sym} 9030 -2350 0 0 {name=p3434 lab=_1530_/Y }
C {devices/lab_pin.sym} 9190 -2410 0 1 {name=p3435 lab=_1602_/A }
C {sky130_stdcells/a211o_4.sym} 9110 -2410 0 0 {name=X_1599_ }
C {devices/lab_pin.sym} 9070 -2260 0 0 {name=p3436 lab=clkbuf_4_3_0_m1_clk_local/A }
C {devices/lab_pin.sym} 9150 -2260 0 1 {name=p3437 lab=_2528_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 9110 -2260 0 0 {name=Xclkbuf_4_2_0_m1_clk_local }
C {devices/lab_pin.sym} 9020 -2140 0 0 {name=p3438 lab=_2638_/CLK }
C {devices/lab_pin.sym} 9020 -2120 0 0 {name=p3439 lab=_2640_/D }
C {devices/lab_pin.sym} 9200 -2140 0 1 {name=p3440 lab=_1277_/D }
C {sky130_stdcells/dfxtp_4.sym} 9110 -2130 0 0 {name=X_2640_ }
C {devices/lab_pin.sym} 9020 -2000 0 0 {name=p3441 lab=_2457_/CLK }
C {devices/lab_pin.sym} 9020 -1980 0 0 {name=p3442 lab=_2571_/D }
C {devices/lab_pin.sym} 9200 -2000 0 1 {name=p3443 lab=_1829_/A }
C {sky130_stdcells/dfxtp_4.sym} 9110 -1990 0 0 {name=X_2571_ }
C {devices/lab_pin.sym} 9030 -1880 0 0 {name=p3444 lab=_1473_/B }
C {devices/lab_pin.sym} 9030 -1840 0 0 {name=p3445 lab=_1448_/A }
C {devices/lab_pin.sym} 9030 -1800 0 0 {name=p3446 lab=_1213_/X }
C {devices/lab_pin.sym} 9190 -1840 0 1 {name=p3447 lab=_1522_/Y }
C {sky130_stdcells/o21ai_4.sym} 9110 -1840 0 0 {name=X_1522_ }
C {devices/lab_pin.sym} 9030 -1720 0 0 {name=p3448 lab=_1450_/X }
C {devices/lab_pin.sym} 9030 -1680 0 0 {name=p3449 lab=_1452_/Y }
C {devices/lab_pin.sym} 9030 -1640 0 0 {name=p3450 lab=_2335_/B }
C {devices/lab_pin.sym} 9190 -1680 0 1 {name=p3451 lab=_1453_/Y }
C {sky130_stdcells/o21ai_4.sym} 9110 -1680 0 0 {name=X_1453_ }
C {devices/lab_pin.sym} 4390 -21950 0 0 {name=p3452 lab=_2011_/A }
C {devices/lab_pin.sym} 4390 -21910 0 0 {name=p3453 lab=_2020_/A }
C {devices/lab_pin.sym} 4390 -21870 0 0 {name=p3454 lab=_2492_/Q }
C {devices/lab_pin.sym} 4390 -21830 0 0 {name=p3455 lab=CLK_LED }
C {devices/lab_pin.sym} 4510 -21890 0 1 {name=p3456 lab=_2005_/Y }
C {sky130_stdcells/nand4_4.sym} 4450 -21890 0 0 {name=X_2005_ }
C {devices/lab_pin.sym} 4370 -21760 0 0 {name=p3457 lab=_1385_/A }
C {devices/lab_pin.sym} 4370 -21720 0 0 {name=p3458 lab=_1390_/B }
C {devices/lab_pin.sym} 4370 -21680 0 0 {name=p3459 lab=_1374_/X }
C {devices/lab_pin.sym} 4530 -21720 0 1 {name=p3460 lab=_1384_/X }
C {sky130_stdcells/o21a_4.sym} 4450 -21720 0 0 {name=X_1384_ }
C {sky130_stdcells/decap_3.sym} 4450 -21550 0 0 {name=XPHY_64 }
C {sky130_stdcells/decap_3.sym} 4450 -21370 0 0 {name=XPHY_53 }
C {sky130_stdcells/decap_3.sym} 4450 -21190 0 0 {name=XPHY_20 }
C {sky130_stdcells/decap_3.sym} 4450 -21010 0 0 {name=XPHY_31 }
C {sky130_stdcells/decap_3.sym} 4450 -20830 0 0 {name=XPHY_42 }
C {sky130_stdcells/decap_3.sym} 4450 -20650 0 0 {name=XPHY_97 }
C {sky130_stdcells/decap_3.sym} 4450 -20470 0 0 {name=XPHY_86 }
C {sky130_stdcells/decap_3.sym} 4450 -20290 0 0 {name=XPHY_75 }
C {devices/lab_pin.sym} 4360 -20140 0 0 {name=p3461 lab=_2554_/CLK }
C {devices/lab_pin.sym} 4360 -20120 0 0 {name=p3462 lab=_1887_/X }
C {devices/lab_pin.sym} 4540 -20140 0 1 {name=p3463 lab=_2554_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -20130 0 0 {name=X_2554_ }
C {devices/lab_pin.sym} 4360 -20000 0 0 {name=p3464 lab=_2367_/CLK }
C {devices/lab_pin.sym} 4360 -19980 0 0 {name=p3465 lab=_2623_/D }
C {devices/lab_pin.sym} 4540 -20000 0 1 {name=p3466 lab=_2623_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -19990 0 0 {name=X_2623_ }
C {devices/lab_pin.sym} 4360 -19860 0 0 {name=p3467 lab=_2483_/CLK }
C {devices/lab_pin.sym} 4360 -19840 0 0 {name=p3468 lab=_2044_/X }
C {devices/lab_pin.sym} 4540 -19860 0 1 {name=p3469 lab=_2043_/D }
C {sky130_stdcells/dfxtp_4.sym} 4450 -19850 0 0 {name=X_2485_ }
C {devices/lab_pin.sym} 4390 -19750 0 0 {name=p3470 lab=_1367_/A }
C {devices/lab_pin.sym} 4390 -19710 0 0 {name=p3471 lab=_1366_/X }
C {devices/lab_pin.sym} 4390 -19670 0 0 {name=p3472 lab=_1360_/A }
C {devices/lab_pin.sym} 4390 -19630 0 0 {name=p3473 lab=_1238_/D }
C {devices/lab_pin.sym} 4510 -19690 0 1 {name=p3474 lab=_1367_/Y }
C {sky130_stdcells/nand4_4.sym} 4450 -19690 0 0 {name=X_1367_ }
C {devices/lab_pin.sym} 4390 -19570 0 0 {name=p3475 lab=_2609_/Q }
C {devices/lab_pin.sym} 4390 -19530 0 0 {name=p3476 lab=_1436_/B }
C {devices/lab_pin.sym} 4390 -19490 0 0 {name=p3477 lab=_1436_/C }
C {devices/lab_pin.sym} 4390 -19450 0 0 {name=p3478 lab=_1486_/A }
C {devices/lab_pin.sym} 4510 -19510 0 1 {name=p3479 lab=_1438_/A }
C {sky130_stdcells/and4_4.sym} 4450 -19510 0 0 {name=X_1436_ }
C {devices/lab_pin.sym} 4390 -19390 0 0 {name=p3480 lab=_1505_/A }
C {devices/lab_pin.sym} 4390 -19350 0 0 {name=p3481 lab=_1505_/B }
C {devices/lab_pin.sym} 4390 -19310 0 0 {name=p3482 lab=_1505_/C }
C {devices/lab_pin.sym} 4390 -19270 0 0 {name=p3483 lab=_1435_/Y }
C {devices/lab_pin.sym} 4510 -19330 0 1 {name=p3484 lab=_1505_/Y }
C {sky130_stdcells/nand4_4.sym} 4450 -19330 0 0 {name=X_1505_ }
C {devices/lab_pin.sym} 4410 -19180 0 0 {name=p3485 lab=_1270_/A }
C {devices/lab_pin.sym} 4490 -19180 0 1 {name=p3486 lab=_2006_/B }
C {sky130_stdcells/buf_2.sym} 4450 -19180 0 0 {name=X_1298_ }
C {devices/lab_pin.sym} 4410 -19060 0 0 {name=p3487 lab=_1221_/A }
C {devices/lab_pin.sym} 4490 -19060 0 1 {name=p3488 lab=_1222_/A }
C {sky130_stdcells/buf_2.sym} 4450 -19060 0 0 {name=X_1221_ }
C {devices/lab_pin.sym} 4410 -18940 0 0 {name=p3489 lab=_2246_/Y }
C {devices/lab_pin.sym} 4490 -18940 0 1 {name=p3490 lab=_2270_/X }
C {sky130_stdcells/buf_2.sym} 4450 -18940 0 0 {name=X_2270_ }
C {devices/lab_pin.sym} 4410 -18820 0 0 {name=p3491 lab=_1985_/A }
C {devices/lab_pin.sym} 4490 -18820 0 1 {name=p3492 lab=_1985_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -18820 0 0 {name=X_1985_ }
C {devices/lab_pin.sym} 4360 -18700 0 0 {name=p3493 lab=_2506_/CLK }
C {devices/lab_pin.sym} 4360 -18680 0 0 {name=p3494 lab=_2537_/D }
C {devices/lab_pin.sym} 4540 -18700 0 1 {name=p3495 lab=_2537_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -18690 0 0 {name=X_2537_ }
C {devices/lab_pin.sym} 4360 -18560 0 0 {name=p3496 lab=_2606_/CLK }
C {devices/lab_pin.sym} 4360 -18540 0 0 {name=p3497 lab=_2606_/D }
C {devices/lab_pin.sym} 4540 -18560 0 1 {name=p3498 lab=_1486_/A }
C {sky130_stdcells/dfxtp_4.sym} 4450 -18550 0 0 {name=X_2606_ }
C {devices/lab_pin.sym} 4390 -18440 0 0 {name=p3499 lab=_1419_/A }
C {devices/lab_pin.sym} 4390 -18400 0 0 {name=p3500 lab=_2010_/B }
C {devices/lab_pin.sym} 4390 -18360 0 0 {name=p3501 lab=_1419_/C }
C {devices/lab_pin.sym} 4510 -18400 0 1 {name=p3502 lab=_1419_/X }
C {sky130_stdcells/and3_4.sym} 4450 -18400 0 0 {name=X_1419_ }
C {devices/lab_pin.sym} 4360 -18260 0 0 {name=p3503 lab=_2570_/CLK }
C {devices/lab_pin.sym} 4360 -18240 0 0 {name=p3504 lab=_2092_/Y }
C {devices/lab_pin.sym} 4540 -18260 0 1 {name=p3505 lab=_2468_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -18250 0 0 {name=X_2468_ }
C {devices/lab_pin.sym} 4360 -18120 0 0 {name=p3506 lab=_2606_/CLK }
C {devices/lab_pin.sym} 4360 -18100 0 0 {name=p3507 lab=_2399_/D }
C {devices/lab_pin.sym} 4540 -18120 0 1 {name=p3508 lab=_1750_/A }
C {sky130_stdcells/dfxtp_4.sym} 4450 -18110 0 0 {name=X_2399_ }
C {devices/lab_pin.sym} 4410 -17980 0 0 {name=p3509 lab=_1769_/X }
C {devices/lab_pin.sym} 4490 -17980 0 1 {name=p3510 lab=_1783_/B }
C {sky130_stdcells/inv_2.sym} 4450 -17980 0 0 {name=X_1770_ }
C {devices/lab_pin.sym} 4370 -17880 0 0 {name=p3511 lab=_2170_/B }
C {devices/lab_pin.sym} 4370 -17840 0 0 {name=p3512 lab=_1216_/B }
C {devices/lab_pin.sym} 4370 -17800 0 0 {name=p3513 lab=_1191_/X }
C {devices/lab_pin.sym} 4530 -17840 0 1 {name=p3514 lab=_1204_/Y }
C {sky130_stdcells/o21ai_4.sym} 4450 -17840 0 0 {name=X_1204_ }
C {devices/lab_pin.sym} 4390 -17710 0 0 {name=p3515 lab=_2322_/A }
C {devices/lab_pin.sym} 4390 -17670 0 0 {name=p3516 lab=_2392_/Q }
C {devices/lab_pin.sym} 4510 -17690 0 1 {name=p3517 lab=_2322_/Y }
C {sky130_stdcells/nand2_4.sym} 4450 -17690 0 0 {name=X_2322_ }
C {devices/lab_pin.sym} 4370 -17590 0 0 {name=p3518 lab=_1225_/A }
C {devices/lab_pin.sym} 4370 -17550 0 0 {name=p3519 lab=_2148_/X }
C {devices/lab_pin.sym} 4370 -17510 0 0 {name=p3520 lab=_1651_/X }
C {devices/lab_pin.sym} 4370 -17470 0 0 {name=p3521 lab=_1649_/Y }
C {devices/lab_pin.sym} 4530 -17530 0 1 {name=p3522 lab=_2184_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 4450 -17530 0 0 {name=X_2184_ }
C {devices/lab_pin.sym} 4390 -17400 0 0 {name=p3523 lab=_2257_/A }
C {devices/lab_pin.sym} 4390 -17360 0 0 {name=p3524 lab=_1698_/A }
C {devices/lab_pin.sym} 4390 -17320 0 0 {name=p3525 lab=_2253_/C }
C {devices/lab_pin.sym} 4510 -17360 0 1 {name=p3526 lab=_2253_/Y }
C {sky130_stdcells/nand3_4.sym} 4450 -17360 0 0 {name=X_2253_ }
C {devices/lab_pin.sym} 4390 -17230 0 0 {name=p3527 lab=_1900_/A }
C {devices/lab_pin.sym} 4390 -17190 0 0 {name=p3528 lab=_1899_/B }
C {devices/lab_pin.sym} 4510 -17210 0 1 {name=p3529 lab=_1899_/X }
C {sky130_stdcells/and2_4.sym} 4450 -17210 0 0 {name=X_1899_ }
C {devices/lab_pin.sym} 4390 -17090 0 0 {name=p3530 lab=_1969_/A }
C {devices/lab_pin.sym} 4390 -17050 0 0 {name=p3531 lab=_1968_/B }
C {devices/lab_pin.sym} 4510 -17070 0 1 {name=p3532 lab=_2502_/D }
C {sky130_stdcells/and2_4.sym} 4450 -17070 0 0 {name=X_1968_ }
C {devices/lab_pin.sym} 4370 -16960 0 0 {name=p3533 lab=_2574_/Q }
C {devices/lab_pin.sym} 4370 -16920 0 0 {name=p3534 lab=_2461_/Q }
C {devices/lab_pin.sym} 4370 -16880 0 0 {name=p3535 lab=_1813_/X }
C {devices/lab_pin.sym} 4530 -16920 0 1 {name=p3536 lab=_1822_/X }
C {sky130_stdcells/o21a_4.sym} 4450 -16920 0 0 {name=X_1822_ }
C {devices/lab_pin.sym} 4370 -16800 0 0 {name=p3537 lab=_1749_/X }
C {devices/lab_pin.sym} 4370 -16760 0 0 {name=p3538 lab=_1752_/X }
C {devices/lab_pin.sym} 4370 -16720 0 0 {name=p3539 lab=_1471_/X }
C {devices/lab_pin.sym} 4530 -16760 0 1 {name=p3540 lab=_1753_/X }
C {sky130_stdcells/a21o_4.sym} 4450 -16760 0 0 {name=X_1753_ }
C {devices/lab_pin.sym} 4390 -16640 0 0 {name=p3541 lab=_1575_/Y }
C {devices/lab_pin.sym} 4390 -16600 0 0 {name=p3542 lab=_1683_/Y }
C {devices/lab_pin.sym} 4390 -16560 0 0 {name=p3543 lab=_1444_/Y }
C {devices/lab_pin.sym} 4510 -16600 0 1 {name=p3544 lab=_1684_/Y }
C {sky130_stdcells/nand3_4.sym} 4450 -16600 0 0 {name=X_1684_ }
C {devices/lab_pin.sym} 4370 -16480 0 0 {name=p3545 lab=_2147_/Y }
C {devices/lab_pin.sym} 4370 -16440 0 0 {name=p3546 lab=_2165_/Y }
C {devices/lab_pin.sym} 4370 -16400 0 0 {name=p3547 lab=_2166_/Y }
C {devices/lab_pin.sym} 4530 -16440 0 1 {name=p3548 lab=_2167_/Y }
C {sky130_stdcells/o21ai_4.sym} 4450 -16440 0 0 {name=X_2167_ }
C {devices/lab_pin.sym} 4390 -16310 0 0 {name=p3549 lab=_1662_/A }
C {devices/lab_pin.sym} 4390 -16270 0 0 {name=p3550 lab=_1218_/A }
C {devices/lab_pin.sym} 4510 -16290 0 1 {name=p3551 lab=_2236_/Y }
C {sky130_stdcells/nor2_4.sym} 4450 -16290 0 0 {name=X_2236_ }
C {devices/lab_pin.sym} 4370 -16180 0 0 {name=p3552 lab=_1503_/Y }
C {devices/lab_pin.sym} 4370 -16140 0 0 {name=p3553 lab=_2292_/X }
C {devices/lab_pin.sym} 4370 -16100 0 0 {name=p3554 lab=_2304_/Y }
C {devices/lab_pin.sym} 4530 -16140 0 1 {name=p3555 lab=_2305_/Y }
C {sky130_stdcells/o21ai_4.sym} 4450 -16140 0 0 {name=X_2305_ }
C {devices/lab_pin.sym} 4410 -16000 0 0 {name=p3556 lab=_2452_/Q }
C {devices/lab_pin.sym} 4490 -16000 0 1 {name=p3557 lab=_2098_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -16000 0 0 {name=X_2098_ }
C {devices/lab_pin.sym} 4410 -15880 0 0 {name=p3558 lab=clkbuf_3_5_0_m1_clk_local/X }
C {devices/lab_pin.sym} 4490 -15880 0 1 {name=p3559 lab=_2513_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4450 -15880 0 0 {name=Xclkbuf_4_10_0_m1_clk_local }
C {devices/lab_pin.sym} 4370 -15780 0 0 {name=p3560 lab=_2002_/X }
C {devices/lab_pin.sym} 4370 -15740 0 0 {name=p3561 lab=_2013_/D }
C {devices/lab_pin.sym} 4370 -15700 0 0 {name=p3562 lab=_2003_/Y }
C {devices/lab_pin.sym} 4530 -15740 0 1 {name=p3563 lab=_2021_/Y }
C {sky130_stdcells/o21ai_4.sym} 4450 -15740 0 0 {name=X_2021_ }
C {devices/lab_pin.sym} 4390 -15610 0 0 {name=p3564 lab=_1736_/A }
C {devices/lab_pin.sym} 4390 -15570 0 0 {name=p3565 lab=_2463_/Q }
C {devices/lab_pin.sym} 4510 -15590 0 1 {name=p3566 lab=_1831_/B }
C {sky130_stdcells/nor2_4.sym} 4450 -15590 0 0 {name=X_1736_ }
C {devices/lab_pin.sym} 4370 -15480 0 0 {name=p3567 lab=_1786_/Y }
C {devices/lab_pin.sym} 4370 -15440 0 0 {name=p3568 lab=_2573_/Q }
C {devices/lab_pin.sym} 4370 -15400 0 0 {name=p3569 lab=_1804_/X }
C {devices/lab_pin.sym} 4530 -15440 0 1 {name=p3570 lab=_1805_/X }
C {sky130_stdcells/o21a_4.sym} 4450 -15440 0 0 {name=X_1805_ }
C {devices/lab_pin.sym} 4390 -15330 0 0 {name=p3571 lab=_1667_/A }
C {devices/lab_pin.sym} 4390 -15290 0 0 {name=p3572 lab=_1667_/B }
C {devices/lab_pin.sym} 4390 -15250 0 0 {name=p3573 lab=_1667_/C }
C {devices/lab_pin.sym} 4390 -15210 0 0 {name=p3574 lab=_1667_/D }
C {devices/lab_pin.sym} 4510 -15270 0 1 {name=p3575 lab=_1667_/X }
C {sky130_stdcells/and4_4.sym} 4450 -15270 0 0 {name=X_1667_ }
C {devices/lab_pin.sym} 4370 -15140 0 0 {name=p3576 lab=_1443_/A }
C {devices/lab_pin.sym} 4370 -15100 0 0 {name=p3577 lab=_2390_/Q }
C {devices/lab_pin.sym} 4370 -15060 0 0 {name=p3578 lab=_1520_/A }
C {devices/lab_pin.sym} 4530 -15100 0 1 {name=p3579 lab=_1598_/X }
C {sky130_stdcells/o21a_4.sym} 4450 -15100 0 0 {name=X_1598_ }
C {devices/lab_pin.sym} 4370 -14980 0 0 {name=p3580 lab=_2089_/Y }
C {devices/lab_pin.sym} 4370 -14940 0 0 {name=p3581 lab=_1624_/X }
C {devices/lab_pin.sym} 4370 -14900 0 0 {name=p3582 lab=_2218_/Y }
C {devices/lab_pin.sym} 4530 -14940 0 1 {name=p3583 lab=_2219_/Y }
C {sky130_stdcells/o21ai_4.sym} 4450 -14940 0 0 {name=X_2219_ }
C {devices/lab_pin.sym} 4360 -14800 0 0 {name=p3584 lab=_2570_/CLK }
C {devices/lab_pin.sym} 4360 -14780 0 0 {name=p3585 lab=_2570_/D }
C {devices/lab_pin.sym} 4540 -14800 0 1 {name=p3586 lab=_1735_/C }
C {sky130_stdcells/dfxtp_4.sym} 4450 -14790 0 0 {name=X_2570_ }
C {devices/lab_pin.sym} 4390 -14690 0 0 {name=p3587 lab=_1383_/A }
C {devices/lab_pin.sym} 4390 -14650 0 0 {name=p3588 lab=_2621_/Q }
C {devices/lab_pin.sym} 4390 -14610 0 0 {name=p3589 lab=_1383_/C }
C {devices/lab_pin.sym} 4390 -14570 0 0 {name=p3590 lab=_2619_/Q }
C {devices/lab_pin.sym} 4510 -14630 0 1 {name=p3591 lab=_1390_/B }
C {sky130_stdcells/and4_4.sym} 4450 -14630 0 0 {name=X_1383_ }
C {devices/lab_pin.sym} 4370 -14500 0 0 {name=p3592 lab=_1440_/B }
C {devices/lab_pin.sym} 4370 -14460 0 0 {name=p3593 lab=_1440_/D }
C {devices/lab_pin.sym} 4370 -14420 0 0 {name=p3594 lab=_1451_/X }
C {devices/lab_pin.sym} 4530 -14460 0 1 {name=p3595 lab=_1452_/Y }
C {sky130_stdcells/a21oi_4.sym} 4450 -14460 0 0 {name=X_1452_ }
C {devices/lab_pin.sym} 4370 -14340 0 0 {name=p3596 lab=_1520_/X }
C {devices/lab_pin.sym} 4370 -14300 0 0 {name=p3597 lab=_1460_/X }
C {devices/lab_pin.sym} 4370 -14260 0 0 {name=p3598 lab=_1462_/X }
C {devices/lab_pin.sym} 4530 -14300 0 1 {name=p3599 lab=_1521_/Y }
C {sky130_stdcells/a21oi_4.sym} 4450 -14300 0 0 {name=X_1521_ }
C {devices/lab_pin.sym} 4390 -14180 0 0 {name=p3600 lab=_2002_/X }
C {devices/lab_pin.sym} 4390 -14140 0 0 {name=p3601 lab=_2003_/Y }
C {devices/lab_pin.sym} 4390 -14100 0 0 {name=p3602 lab=_2008_/A }
C {devices/lab_pin.sym} 4510 -14140 0 1 {name=p3603 lab=_2020_/A }
C {sky130_stdcells/nor3_4.sym} 4450 -14140 0 0 {name=X_2004_ }
C {devices/lab_pin.sym} 4410 -14000 0 0 {name=p3604 lab=clkbuf_4_7_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 4490 -14000 0 1 {name=p3605 lab=_2554_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4450 -14000 0 0 {name=Xclkbuf_4_7_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 4390 -13890 0 0 {name=p3606 lab=_1719_/A }
C {devices/lab_pin.sym} 4390 -13850 0 0 {name=p3607 lab=_1640_/X }
C {devices/lab_pin.sym} 4510 -13870 0 1 {name=p3608 lab=_1719_/X }
C {sky130_stdcells/or2_4.sym} 4450 -13870 0 0 {name=X_1719_ }
C {sky130_stdcells/decap_3.sym} 4450 -13710 0 0 {name=XPHY_98 }
C {sky130_stdcells/decap_3.sym} 4450 -13530 0 0 {name=XPHY_87 }
C {sky130_stdcells/decap_3.sym} 4450 -13350 0 0 {name=XPHY_76 }
C {sky130_stdcells/decap_3.sym} 4450 -13170 0 0 {name=XPHY_65 }
C {sky130_stdcells/decap_3.sym} 4450 -12990 0 0 {name=XPHY_54 }
C {sky130_stdcells/decap_3.sym} 4450 -12810 0 0 {name=XPHY_10 }
C {sky130_stdcells/decap_3.sym} 4450 -12630 0 0 {name=XPHY_21 }
C {sky130_stdcells/decap_3.sym} 4450 -12450 0 0 {name=XPHY_32 }
C {sky130_stdcells/decap_3.sym} 4450 -12270 0 0 {name=XPHY_43 }
C {devices/lab_pin.sym} 4360 -12120 0 0 {name=p3609 lab=_2550_/CLK }
C {devices/lab_pin.sym} 4360 -12100 0 0 {name=p3610 lab=_2553_/D }
C {devices/lab_pin.sym} 4540 -12120 0 1 {name=p3611 lab=_2553_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -12110 0 0 {name=X_2553_ }
C {devices/lab_pin.sym} 4360 -11980 0 0 {name=p3612 lab=_2367_/CLK }
C {devices/lab_pin.sym} 4360 -11960 0 0 {name=p3613 lab=_2622_/D }
C {devices/lab_pin.sym} 4540 -11980 0 1 {name=p3614 lab=_1385_/A }
C {sky130_stdcells/dfxtp_4.sym} 4450 -11970 0 0 {name=X_2622_ }
C {devices/lab_pin.sym} 4410 -11840 0 0 {name=p3615 lab=_1494_/B }
C {devices/lab_pin.sym} 4490 -11840 0 1 {name=p3616 lab=_1505_/A }
C {sky130_stdcells/inv_2.sym} 4450 -11840 0 0 {name=X_1504_ }
C {devices/lab_pin.sym} 4360 -11720 0 0 {name=p3617 lab=_2470_/CLK }
C {devices/lab_pin.sym} 4360 -11700 0 0 {name=p3618 lab=_2046_/Y }
C {devices/lab_pin.sym} 4540 -11720 0 1 {name=p3619 lab=_1987_/A }
C {sky130_stdcells/dfxtp_4.sym} 4450 -11710 0 0 {name=X_2484_ }
C {devices/lab_pin.sym} 4410 -11580 0 0 {name=p3620 lab=_1365_/X }
C {devices/lab_pin.sym} 4490 -11580 0 1 {name=p3621 lab=_1366_/X }
C {sky130_stdcells/buf_2.sym} 4450 -11580 0 0 {name=X_1366_ }
C {devices/lab_pin.sym} 4410 -11460 0 0 {name=p3622 lab=_1434_/Y }
C {devices/lab_pin.sym} 4490 -11460 0 1 {name=p3623 lab=_1435_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -11460 0 0 {name=X_1435_ }
C {devices/lab_pin.sym} 4410 -11340 0 0 {name=p3624 lab=_1296_/Y }
C {devices/lab_pin.sym} 4490 -11340 0 1 {name=p3625 lab=_2638_/D }
C {sky130_stdcells/inv_2.sym} 4450 -11340 0 0 {name=X_1297_ }
C {devices/lab_pin.sym} 4410 -11220 0 0 {name=p3626 lab=_1219_/X }
C {devices/lab_pin.sym} 4490 -11220 0 1 {name=p3627 lab=_1221_/A }
C {sky130_stdcells/buf_2.sym} 4450 -11220 0 0 {name=X_1220_ }
C {devices/lab_pin.sym} 4410 -11100 0 0 {name=p3628 lab=_1984_/A }
C {devices/lab_pin.sym} 4490 -11100 0 1 {name=p3629 lab=_1998_/A }
C {sky130_stdcells/inv_2.sym} 4450 -11100 0 0 {name=X_1984_ }
C {devices/lab_pin.sym} 4360 -10980 0 0 {name=p3630 lab=_2457_/CLK }
C {devices/lab_pin.sym} 4360 -10960 0 0 {name=p3631 lab=_2467_/D }
C {devices/lab_pin.sym} 4540 -10980 0 1 {name=p3632 lab=_2467_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -10970 0 0 {name=X_2467_ }
C {devices/lab_pin.sym} 4360 -10840 0 0 {name=p3633 lab=_2519_/CLK }
C {devices/lab_pin.sym} 4360 -10820 0 0 {name=p3634 lab=_1916_/X }
C {devices/lab_pin.sym} 4540 -10840 0 1 {name=p3635 lab=HASH_ADDR[5] }
C {sky130_stdcells/dfxtp_4.sym} 4450 -10830 0 0 {name=X_2536_ }
C {devices/lab_pin.sym} 4360 -10700 0 0 {name=p3636 lab=_2388_/CLK }
C {devices/lab_pin.sym} 4360 -10680 0 0 {name=p3637 lab=_2605_/D }
C {devices/lab_pin.sym} 4540 -10700 0 1 {name=p3638 lab=_1483_/B }
C {sky130_stdcells/dfxtp_4.sym} 4450 -10690 0 0 {name=X_2605_ }
C {devices/lab_pin.sym} 4410 -10560 0 0 {name=p3639 lab=_1349_/A }
C {devices/lab_pin.sym} 4490 -10560 0 1 {name=p3640 lab=_1349_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -10560 0 0 {name=X_1349_ }
C {devices/lab_pin.sym} 4390 -10450 0 0 {name=p3641 lab=_1409_/A }
C {devices/lab_pin.sym} 4390 -10410 0 0 {name=p3642 lab=_1409_/C }
C {devices/lab_pin.sym} 4510 -10430 0 1 {name=p3643 lab=_1419_/A }
C {sky130_stdcells/or2_4.sym} 4450 -10430 0 0 {name=X_1418_ }
C {devices/lab_pin.sym} 4360 -10300 0 0 {name=p3644 lab=_2606_/CLK }
C {devices/lab_pin.sym} 4360 -10280 0 0 {name=p3645 lab=_2318_/X }
C {devices/lab_pin.sym} 4540 -10300 0 1 {name=p3646 lab=_1773_/A }
C {sky130_stdcells/dfxtp_4.sym} 4450 -10290 0 0 {name=X_2398_ }
C {devices/lab_pin.sym} 4370 -10190 0 0 {name=p3647 lab=_2223_/Y }
C {devices/lab_pin.sym} 4370 -10150 0 0 {name=p3648 lab=_2310_/X }
C {devices/lab_pin.sym} 4370 -10110 0 0 {name=p3649 lab=_1520_/X }
C {devices/lab_pin.sym} 4370 -10070 0 0 {name=p3650 lab=_2312_/X }
C {devices/lab_pin.sym} 4530 -10130 0 1 {name=p3651 lab=_2395_/D }
C {sky130_stdcells/a2bb2o_4.sym} 4450 -10130 0 0 {name=X_2321_ }
C {devices/lab_pin.sym} 4370 -10000 0 0 {name=p3652 lab=_2647_/Q }
C {devices/lab_pin.sym} 4370 -9960 0 0 {name=p3653 lab=_1194_/B }
C {devices/lab_pin.sym} 4370 -9920 0 0 {name=p3654 lab=_1202_/X }
C {devices/lab_pin.sym} 4530 -9960 0 1 {name=p3655 lab=_1203_/Y }
C {sky130_stdcells/o21ai_4.sym} 4450 -9960 0 0 {name=X_1203_ }
C {devices/lab_pin.sym} 4370 -9860 0 0 {name=p3656 lab=_2244_/X }
C {devices/lab_pin.sym} 4370 -9820 0 0 {name=p3657 lab=_2133_/Y }
C {devices/lab_pin.sym} 4370 -9780 0 0 {name=p3658 lab=_2247_/X }
C {devices/lab_pin.sym} 4370 -9740 0 0 {name=p3659 lab=_1905_/B }
C {devices/lab_pin.sym} 4370 -9700 0 0 {name=p3660 lab=_2249_/X }
C {devices/lab_pin.sym} 4530 -9780 0 1 {name=p3661 lab=_2431_/D }
C {sky130_stdcells/o32ai_4.sym} 4450 -9780 0 0 {name=X_2252_ }
C {devices/lab_pin.sym} 4370 -9640 0 0 {name=p3662 lab=_2180_/X }
C {devices/lab_pin.sym} 4370 -9600 0 0 {name=p3663 lab=_2182_/X }
C {devices/lab_pin.sym} 4370 -9560 0 0 {name=p3664 lab=_1701_/A }
C {devices/lab_pin.sym} 4530 -9600 0 1 {name=p3665 lab=_2183_/Y }
C {sky130_stdcells/a21oi_4.sym} 4450 -9600 0 0 {name=X_2183_ }
C {devices/lab_pin.sym} 4410 -9460 0 0 {name=p3666 lab=_2096_/A }
C {devices/lab_pin.sym} 4490 -9460 0 1 {name=p3667 lab=_1900_/A }
C {sky130_stdcells/buf_2.sym} 4450 -9460 0 0 {name=X_1898_ }
C {devices/lab_pin.sym} 4390 -9350 0 0 {name=p3668 lab=_1284_/X }
C {devices/lab_pin.sym} 4390 -9310 0 0 {name=p3669 lab=_1966_/Y }
C {devices/lab_pin.sym} 4510 -9330 0 1 {name=p3670 lab=_2503_/D }
C {sky130_stdcells/nor2_4.sym} 4450 -9330 0 0 {name=X_1967_ }
C {devices/lab_pin.sym} 4360 -9200 0 0 {name=p3671 lab=_2519_/CLK }
C {devices/lab_pin.sym} 4360 -9180 0 0 {name=p3672 lab=_1940_/Y }
C {devices/lab_pin.sym} 4540 -9200 0 1 {name=p3673 lab=_2519_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -9190 0 0 {name=X_2519_ }
C {devices/lab_pin.sym} 4410 -9060 0 0 {name=p3674 lab=_1683_/A }
C {devices/lab_pin.sym} 4490 -9060 0 1 {name=p3675 lab=_1683_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -9060 0 0 {name=X_1683_ }
C {devices/lab_pin.sym} 4370 -8960 0 0 {name=p3676 lab=_2574_/Q }
C {devices/lab_pin.sym} 4370 -8920 0 0 {name=p3677 lab=_1809_/X }
C {devices/lab_pin.sym} 4370 -8880 0 0 {name=p3678 lab=_1820_/X }
C {devices/lab_pin.sym} 4530 -8920 0 1 {name=p3679 lab=_2575_/D }
C {sky130_stdcells/o21a_4.sym} 4450 -8920 0 0 {name=X_1821_ }
C {devices/lab_pin.sym} 4370 -8810 0 0 {name=p3680 lab=_2134_/C }
C {devices/lab_pin.sym} 4370 -8770 0 0 {name=p3681 lab=_1751_/A }
C {devices/lab_pin.sym} 4370 -8730 0 0 {name=p3682 lab=_1633_/X }
C {devices/lab_pin.sym} 4370 -8690 0 0 {name=p3683 lab=_1751_/Y }
C {devices/lab_pin.sym} 4530 -8750 0 1 {name=p3684 lab=_1752_/X }
C {sky130_stdcells/a211o_4.sym} 4450 -8750 0 0 {name=X_1752_ }
C {devices/lab_pin.sym} 4390 -8620 0 0 {name=p3685 lab=_2304_/A }
C {devices/lab_pin.sym} 4390 -8580 0 0 {name=p3686 lab=_1602_/C }
C {devices/lab_pin.sym} 4390 -8540 0 0 {name=p3687 lab=_1409_/A }
C {devices/lab_pin.sym} 4510 -8580 0 1 {name=p3688 lab=_2304_/Y }
C {sky130_stdcells/nand3_4.sym} 4450 -8580 0 0 {name=X_2304_ }
C {devices/lab_pin.sym} 4390 -8450 0 0 {name=p3689 lab=_2108_/A }
C {devices/lab_pin.sym} 4390 -8410 0 0 {name=p3690 lab=_2097_/B }
C {devices/lab_pin.sym} 4510 -8430 0 1 {name=p3691 lab=_2097_/X }
C {sky130_stdcells/and2_4.sym} 4450 -8430 0 0 {name=X_2097_ }
C {devices/lab_pin.sym} 4390 -8310 0 0 {name=p3692 lab=_2166_/A }
C {devices/lab_pin.sym} 4390 -8270 0 0 {name=p3693 lab=THREAD_COUNT[3] }
C {devices/lab_pin.sym} 4510 -8290 0 1 {name=p3694 lab=_2166_/Y }
C {sky130_stdcells/nand2_4.sym} 4450 -8290 0 0 {name=X_2166_ }
C {devices/lab_pin.sym} 4390 -8170 0 0 {name=p3695 lab=_2233_/Y }
C {devices/lab_pin.sym} 4390 -8130 0 0 {name=p3696 lab=_2234_/X }
C {devices/lab_pin.sym} 4510 -8150 0 1 {name=p3697 lab=_2235_/Y }
C {sky130_stdcells/nand2_4.sym} 4450 -8150 0 0 {name=X_2235_ }
C {devices/lab_pin.sym} 4410 -8020 0 0 {name=p3698 lab=_2020_/A }
C {devices/lab_pin.sym} 4490 -8020 0 1 {name=p3699 lab=_2022_/A }
C {sky130_stdcells/inv_2.sym} 4450 -8020 0 0 {name=X_2020_ }
C {devices/lab_pin.sym} 4390 -7930 0 0 {name=p3700 lab=_1829_/A }
C {devices/lab_pin.sym} 4390 -7890 0 0 {name=p3701 lab=_1179_/A }
C {devices/lab_pin.sym} 4390 -7850 0 0 {name=p3702 lab=_1735_/C }
C {devices/lab_pin.sym} 4390 -7810 0 0 {name=p3703 lab=_1735_/D }
C {devices/lab_pin.sym} 4510 -7870 0 1 {name=p3704 lab=_1831_/A }
C {sky130_stdcells/nand4_4.sym} 4450 -7870 0 0 {name=X_1735_ }
C {devices/lab_pin.sym} 4410 -7720 0 0 {name=p3705 lab=_2146_/A }
C {devices/lab_pin.sym} 4490 -7720 0 1 {name=p3706 lab=_2166_/A }
C {sky130_stdcells/buf_2.sym} 4450 -7720 0 0 {name=X_1666_ }
C {devices/lab_pin.sym} 4370 -7620 0 0 {name=p3707 lab=_2591_/Q }
C {devices/lab_pin.sym} 4370 -7580 0 0 {name=p3708 lab=_1514_/X }
C {devices/lab_pin.sym} 4370 -7540 0 0 {name=p3709 lab=_1799_/X }
C {devices/lab_pin.sym} 4530 -7580 0 1 {name=p3710 lab=_1804_/X }
C {sky130_stdcells/o21a_4.sym} 4450 -7580 0 0 {name=X_1804_ }
C {devices/lab_pin.sym} 4410 -7440 0 0 {name=p3711 lab=_1664_/A }
C {devices/lab_pin.sym} 4490 -7440 0 1 {name=p3712 lab=_1600_/B }
C {sky130_stdcells/buf_2.sym} 4450 -7440 0 0 {name=X_1597_ }
C {devices/lab_pin.sym} 4370 -7340 0 0 {name=p3713 lab=_1534_/A }
C {devices/lab_pin.sym} 4370 -7300 0 0 {name=p3714 lab=_2554_/Q }
C {devices/lab_pin.sym} 4370 -7260 0 0 {name=p3715 lab=_2148_/X }
C {devices/lab_pin.sym} 4530 -7300 0 1 {name=p3716 lab=_2149_/Y }
C {sky130_stdcells/o21ai_4.sym} 4450 -7300 0 0 {name=X_2149_ }
C {devices/lab_pin.sym} 4370 -7180 0 0 {name=p3717 lab=_1625_/X }
C {devices/lab_pin.sym} 4370 -7140 0 0 {name=p3718 lab=_2411_/Q }
C {devices/lab_pin.sym} 4370 -7100 0 0 {name=p3719 lab=_1617_/Y }
C {devices/lab_pin.sym} 4530 -7140 0 1 {name=p3720 lab=_2218_/Y }
C {sky130_stdcells/a21oi_4.sym} 4450 -7140 0 0 {name=X_2218_ }
C {devices/lab_pin.sym} 4410 -7000 0 0 {name=p3721 lab=clkbuf_0_m1_clk_local/X }
C {devices/lab_pin.sym} 4490 -7000 0 1 {name=p3722 lab=clkbuf_2_3_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 4450 -7000 0 0 {name=Xclkbuf_1_1_0_m1_clk_local }
C {devices/lab_pin.sym} 4410 -6880 0 0 {name=p3723 lab=_1520_/A }
C {devices/lab_pin.sym} 4490 -6880 0 1 {name=p3724 lab=_1520_/X }
C {sky130_stdcells/buf_2.sym} 4450 -6880 0 0 {name=X_1520_ }
C {devices/lab_pin.sym} 4370 -6780 0 0 {name=p3725 lab=_1373_/B }
C {devices/lab_pin.sym} 4370 -6740 0 0 {name=p3726 lab=_1366_/X }
C {devices/lab_pin.sym} 4370 -6700 0 0 {name=p3727 lab=_1381_/Y }
C {devices/lab_pin.sym} 4530 -6740 0 1 {name=p3728 lab=_2623_/D }
C {sky130_stdcells/o21a_4.sym} 4450 -6740 0 0 {name=X_1382_ }
C {devices/lab_pin.sym} 4410 -6600 0 0 {name=p3729 lab=clkbuf_3_6_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 4490 -6600 0 1 {name=p3730 lab=_2590_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 4450 -6600 0 0 {name=Xclkbuf_4_12_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 4410 -6480 0 0 {name=p3731 lab=_1434_/Y }
C {devices/lab_pin.sym} 4490 -6480 0 1 {name=p3732 lab=_1451_/X }
C {sky130_stdcells/buf_2.sym} 4450 -6480 0 0 {name=X_1451_ }
C {devices/lab_pin.sym} 4410 -6360 0 0 {name=p3733 lab=_1999_/A }
C {devices/lab_pin.sym} 4490 -6360 0 1 {name=p3734 lab=_2003_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -6360 0 0 {name=X_2003_ }
C {devices/lab_pin.sym} 4390 -6250 0 0 {name=p3735 lab=_1659_/A }
C {devices/lab_pin.sym} 4390 -6210 0 0 {name=p3736 lab=_1649_/B }
C {devices/lab_pin.sym} 4510 -6230 0 1 {name=p3737 lab=_1649_/Y }
C {sky130_stdcells/nor2_4.sym} 4450 -6230 0 0 {name=X_1649_ }
C {devices/lab_pin.sym} 4370 -6120 0 0 {name=p3738 lab=_1702_/Y }
C {devices/lab_pin.sym} 4370 -6080 0 0 {name=p3739 lab=_1717_/Y }
C {devices/lab_pin.sym} 4370 -6040 0 0 {name=p3740 lab=_1614_/X }
C {devices/lab_pin.sym} 4530 -6080 0 1 {name=p3741 lab=_1718_/Y }
C {sky130_stdcells/o21ai_4.sym} 4450 -6080 0 0 {name=X_1718_ }
C {sky130_stdcells/decap_3.sym} 4450 -5910 0 0 {name=XPHY_99 }
C {sky130_stdcells/decap_3.sym} 4450 -5730 0 0 {name=XPHY_88 }
C {sky130_stdcells/decap_3.sym} 4450 -5550 0 0 {name=XPHY_77 }
C {sky130_stdcells/decap_3.sym} 4450 -5370 0 0 {name=XPHY_66 }
C {sky130_stdcells/decap_3.sym} 4450 -5190 0 0 {name=XPHY_55 }
C {sky130_stdcells/decap_3.sym} 4450 -5010 0 0 {name=XPHY_11 }
C {sky130_stdcells/decap_3.sym} 4450 -4830 0 0 {name=XPHY_22 }
C {sky130_stdcells/decap_3.sym} 4450 -4650 0 0 {name=XPHY_33 }
C {sky130_stdcells/decap_3.sym} 4450 -4470 0 0 {name=XPHY_44 }
C {devices/lab_pin.sym} 4360 -4320 0 0 {name=p3742 lab=_2483_/CLK }
C {devices/lab_pin.sym} 4360 -4300 0 0 {name=p3743 lab=_2050_/Y }
C {devices/lab_pin.sym} 4540 -4320 0 1 {name=p3744 lab=_2030_/A }
C {sky130_stdcells/dfxtp_4.sym} 4450 -4310 0 0 {name=X_2483_ }
C {devices/lab_pin.sym} 4360 -4180 0 0 {name=p3745 lab=_2367_/CLK }
C {devices/lab_pin.sym} 4360 -4160 0 0 {name=p3746 lab=_1390_/Y }
C {devices/lab_pin.sym} 4540 -4180 0 1 {name=p3747 lab=_2621_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -4170 0 0 {name=X_2621_ }
C {devices/lab_pin.sym} 4360 -4040 0 0 {name=p3748 lab=_2554_/CLK }
C {devices/lab_pin.sym} 4360 -4020 0 0 {name=p3749 lab=_1889_/X }
C {devices/lab_pin.sym} 4540 -4040 0 1 {name=p3750 lab=_2552_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -4030 0 0 {name=X_2552_ }
C {devices/lab_pin.sym} 4410 -3900 0 0 {name=p3751 lab=_1503_/A }
C {devices/lab_pin.sym} 4490 -3900 0 1 {name=p3752 lab=_1503_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -3900 0 0 {name=X_1503_ }
C {devices/lab_pin.sym} 4390 -3810 0 0 {name=p3753 lab=_1383_/A }
C {devices/lab_pin.sym} 4390 -3770 0 0 {name=p3754 lab=_1383_/C }
C {devices/lab_pin.sym} 4390 -3730 0 0 {name=p3755 lab=_2619_/Q }
C {devices/lab_pin.sym} 4390 -3690 0 0 {name=p3756 lab=_1365_/D }
C {devices/lab_pin.sym} 4510 -3750 0 1 {name=p3757 lab=_1365_/X }
C {sky130_stdcells/and4_4.sym} 4450 -3750 0 0 {name=X_1365_ }
C {devices/lab_pin.sym} 4390 -3610 0 0 {name=p3758 lab=_2386_/Q }
C {devices/lab_pin.sym} 4390 -3570 0 0 {name=p3759 lab=_1566_/A }
C {devices/lab_pin.sym} 4510 -3590 0 1 {name=p3760 lab=_1434_/Y }
C {sky130_stdcells/nor2_4.sym} 4450 -3590 0 0 {name=X_1434_ }
C {devices/lab_pin.sym} 4390 -3470 0 0 {name=p3761 lab=_1296_/A }
C {devices/lab_pin.sym} 4390 -3430 0 0 {name=p3762 lab=_1296_/B }
C {devices/lab_pin.sym} 4510 -3450 0 1 {name=p3763 lab=_1296_/Y }
C {sky130_stdcells/nand2_4.sym} 4450 -3450 0 0 {name=X_1296_ }
C {devices/lab_pin.sym} 4410 -3320 0 0 {name=p3764 lab=clkbuf_3_4_0_m1_clk_local/A }
C {devices/lab_pin.sym} 4490 -3320 0 1 {name=p3765 lab=clkbuf_4_9_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 4450 -3320 0 0 {name=Xclkbuf_3_4_0_m1_clk_local }
C {devices/lab_pin.sym} 4390 -3210 0 0 {name=p3766 lab=_1222_/X }
C {devices/lab_pin.sym} 4390 -3170 0 0 {name=p3767 lab=_1983_/B }
C {devices/lab_pin.sym} 4510 -3190 0 1 {name=p3768 lab=_1983_/Y }
C {sky130_stdcells/nor2_4.sym} 4450 -3190 0 0 {name=X_1983_ }
C {devices/lab_pin.sym} 4360 -3060 0 0 {name=p3769 lab=_2598_/CLK }
C {devices/lab_pin.sym} 4360 -3040 0 0 {name=p3770 lab=_2604_/D }
C {devices/lab_pin.sym} 4540 -3060 0 1 {name=p3771 lab=_2604_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -3050 0 0 {name=X_2604_ }
C {devices/lab_pin.sym} 4360 -2920 0 0 {name=p3772 lab=_2550_/CLK }
C {devices/lab_pin.sym} 4360 -2900 0 0 {name=p3773 lab=_2094_/X }
C {devices/lab_pin.sym} 4540 -2920 0 1 {name=p3774 lab=_2351_/C }
C {sky130_stdcells/dfxtp_4.sym} 4450 -2910 0 0 {name=X_2466_ }
C {devices/lab_pin.sym} 4410 -2780 0 0 {name=p3775 lab=_1417_/A }
C {devices/lab_pin.sym} 4490 -2780 0 1 {name=p3776 lab=_2614_/D }
C {sky130_stdcells/inv_2.sym} 4450 -2780 0 0 {name=X_1417_ }
C {devices/lab_pin.sym} 4360 -2660 0 0 {name=p3777 lab=_2519_/CLK }
C {devices/lab_pin.sym} 4360 -2640 0 0 {name=p3778 lab=_1917_/X }
C {devices/lab_pin.sym} 4540 -2660 0 1 {name=p3779 lab=HASH_ADDR[4] }
C {sky130_stdcells/dfxtp_4.sym} 4450 -2650 0 0 {name=X_2535_ }
C {devices/lab_pin.sym} 4410 -2520 0 0 {name=p3780 lab=_1347_/Y }
C {devices/lab_pin.sym} 4490 -2520 0 1 {name=p3781 lab=_2629_/D }
C {sky130_stdcells/inv_2.sym} 4450 -2520 0 0 {name=X_1348_ }
C {devices/lab_pin.sym} 4410 -2400 0 0 {name=p3782 lab=_1279_/A }
C {devices/lab_pin.sym} 4490 -2400 0 1 {name=p3783 lab=_1279_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -2400 0 0 {name=X_1279_ }
C {devices/lab_pin.sym} 4360 -2280 0 0 {name=p3784 lab=_2410_/CLK }
C {devices/lab_pin.sym} 4360 -2260 0 0 {name=p3785 lab=_2319_/X }
C {devices/lab_pin.sym} 4540 -2280 0 1 {name=p3786 lab=_2397_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -2270 0 0 {name=X_2397_ }
C {devices/lab_pin.sym} 4370 -2180 0 0 {name=p3787 lab=_2244_/X }
C {devices/lab_pin.sym} 4370 -2140 0 0 {name=p3788 lab=_2130_/Y }
C {devices/lab_pin.sym} 4370 -2100 0 0 {name=p3789 lab=_2247_/X }
C {devices/lab_pin.sym} 4370 -2060 0 0 {name=p3790 lab=_1902_/Y }
C {devices/lab_pin.sym} 4370 -2020 0 0 {name=p3791 lab=_2249_/X }
C {devices/lab_pin.sym} 4530 -2100 0 1 {name=p3792 lab=_2432_/D }
C {sky130_stdcells/o32ai_4.sym} 4450 -2100 0 0 {name=X_2251_ }
C {devices/lab_pin.sym} 4370 -1970 0 0 {name=p3793 lab=_1764_/Y }
C {devices/lab_pin.sym} 4370 -1930 0 0 {name=p3794 lab=_2310_/X }
C {devices/lab_pin.sym} 4370 -1890 0 0 {name=p3795 lab=_1514_/X }
C {devices/lab_pin.sym} 4370 -1850 0 0 {name=p3796 lab=_2312_/X }
C {devices/lab_pin.sym} 4530 -1910 0 1 {name=p3797 lab=_2320_/X }
C {sky130_stdcells/a2bb2o_4.sym} 4450 -1910 0 0 {name=X_2320_ }
C {devices/lab_pin.sym} 4390 -1770 0 0 {name=p3798 lab=_2648_/Q }
C {devices/lab_pin.sym} 4390 -1730 0 0 {name=p3799 lab=_1179_/A }
C {devices/lab_pin.sym} 4510 -1750 0 1 {name=p3800 lab=_1202_/X }
C {sky130_stdcells/or2_4.sym} 4450 -1750 0 0 {name=X_1202_ }
C {devices/lab_pin.sym} 4370 -1650 0 0 {name=p3801 lab=_2441_/Q }
C {devices/lab_pin.sym} 4370 -1610 0 0 {name=p3802 lab=_1635_/X }
C {devices/lab_pin.sym} 4370 -1570 0 0 {name=p3803 lab=_1632_/Y }
C {devices/lab_pin.sym} 4370 -1530 0 0 {name=p3804 lab=_2181_/Y }
C {devices/lab_pin.sym} 4530 -1590 0 1 {name=p3805 lab=_2182_/X }
C {sky130_stdcells/a211o_4.sym} 4450 -1590 0 0 {name=X_2182_ }
C {devices/lab_pin.sym} 4410 -1440 0 0 {name=p3806 lab=_1966_/A }
C {devices/lab_pin.sym} 4490 -1440 0 1 {name=p3807 lab=_1966_/Y }
C {sky130_stdcells/inv_2.sym} 4450 -1440 0 0 {name=X_1966_ }
C {devices/lab_pin.sym} 4390 -1330 0 0 {name=p3808 lab=_1896_/A }
C {devices/lab_pin.sym} 4390 -1290 0 0 {name=p3809 lab=_1897_/B }
C {devices/lab_pin.sym} 4510 -1310 0 1 {name=p3810 lab=_2545_/D }
C {sky130_stdcells/and2_4.sym} 4450 -1310 0 0 {name=X_1897_ }
C {devices/lab_pin.sym} 4360 -1180 0 0 {name=p3811 lab=_2598_/CLK }
C {devices/lab_pin.sym} 4360 -1160 0 0 {name=p3812 lab=_2449_/D }
C {devices/lab_pin.sym} 4540 -1180 0 1 {name=p3813 lab=_2449_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -1170 0 0 {name=X_2449_ }
C {devices/lab_pin.sym} 4360 -1040 0 0 {name=p3814 lab=_2528_/CLK }
C {devices/lab_pin.sym} 4360 -1020 0 0 {name=p3815 lab=_2518_/D }
C {devices/lab_pin.sym} 4540 -1040 0 1 {name=p3816 lab=_2518_/Q }
C {sky130_stdcells/dfxtp_4.sym} 4450 -1030 0 0 {name=X_2518_ }
C {devices/lab_pin.sym} 4370 -920 0 0 {name=p3817 lab=_2575_/Q }
C {devices/lab_pin.sym} 4370 -880 0 0 {name=p3818 lab=_1810_/X }
C {devices/lab_pin.sym} 4370 -840 0 0 {name=p3819 lab=_1813_/X }
C {devices/lab_pin.sym} 4530 -880 0 1 {name=p3820 lab=_1820_/X }
C {sky130_stdcells/o21a_4.sym} 4450 -880 0 0 {name=X_1820_ }
C {devices/lab_pin.sym} 9950 -22000 0 0 {name=p3821 lab=_1566_/X }
C {devices/lab_pin.sym} 9950 -21960 0 0 {name=p3822 lab=_1577_/X }
C {devices/lab_pin.sym} 9950 -21920 0 0 {name=p3823 lab=_1683_/A }
C {devices/lab_pin.sym} 9950 -21880 0 0 {name=p3824 lab=_2385_/Q }
C {devices/lab_pin.sym} 9950 -21840 0 0 {name=p3825 lab=_1681_/X }
C {devices/lab_pin.sym} 10110 -21920 0 1 {name=p3826 lab=_1682_/Y }
C {sky130_stdcells/o41ai_4.sym} 10030 -21920 0 0 {name=X_1682_ }
C {devices/lab_pin.sym} 9970 -21770 0 0 {name=p3827 lab=_1751_/A }
C {devices/lab_pin.sym} 9970 -21730 0 0 {name=p3828 lab=_1751_/B }
C {devices/lab_pin.sym} 10090 -21750 0 1 {name=p3829 lab=_1751_/Y }
C {sky130_stdcells/nor2_4.sym} 10030 -21750 0 0 {name=X_1751_ }
C {devices/lab_pin.sym} 9970 -21650 0 0 {name=p3830 lab=_1860_/B }
C {devices/lab_pin.sym} 9970 -21610 0 0 {name=p3831 lab=_2543_/Q }
C {devices/lab_pin.sym} 9970 -21570 0 0 {name=p3832 lab=_1661_/D }
C {devices/lab_pin.sym} 9970 -21530 0 0 {name=p3833 lab=_2234_/D }
C {devices/lab_pin.sym} 10090 -21590 0 1 {name=p3834 lab=_2234_/X }
C {sky130_stdcells/or4_4.sym} 10030 -21590 0 0 {name=X_2234_ }
C {devices/lab_pin.sym} 9950 -21460 0 0 {name=p3835 lab=_2136_/Y }
C {devices/lab_pin.sym} 9950 -21420 0 0 {name=p3836 lab=_2291_/X }
C {devices/lab_pin.sym} 9950 -21380 0 0 {name=p3837 lab=_2302_/Y }
C {devices/lab_pin.sym} 10110 -21420 0 1 {name=p3838 lab=_2303_/Y }
C {sky130_stdcells/o21ai_4.sym} 10030 -21420 0 0 {name=X_2303_ }
C {devices/lab_pin.sym} 9990 -21280 0 0 {name=p3839 lab=_2096_/A }
C {devices/lab_pin.sym} 10070 -21280 0 1 {name=p3840 lab=_2108_/A }
C {sky130_stdcells/buf_2.sym} 10030 -21280 0 0 {name=X_2096_ }
C {devices/lab_pin.sym} 9950 -21180 0 0 {name=p3841 lab=_2162_/Y }
C {devices/lab_pin.sym} 9950 -21140 0 0 {name=p3842 lab=_2163_/X }
C {devices/lab_pin.sym} 9950 -21100 0 0 {name=p3843 lab=_2164_/X }
C {devices/lab_pin.sym} 10110 -21140 0 1 {name=p3844 lab=_2165_/Y }
C {sky130_stdcells/a21oi_4.sym} 10030 -21140 0 0 {name=X_2165_ }
C {devices/lab_pin.sym} 9970 -21010 0 0 {name=p3845 lab=_1947_/A }
C {devices/lab_pin.sym} 9970 -20970 0 0 {name=p3846 lab=_1948_/Y }
C {devices/lab_pin.sym} 10090 -20990 0 1 {name=p3847 lab=_1949_/Y }
C {sky130_stdcells/nor2_4.sym} 10030 -20990 0 0 {name=X_1949_ }
C {devices/lab_pin.sym} 9950 -20880 0 0 {name=p3848 lab=_1786_/Y }
C {devices/lab_pin.sym} 9950 -20840 0 0 {name=p3849 lab=_2574_/Q }
C {devices/lab_pin.sym} 9950 -20800 0 0 {name=p3850 lab=_1802_/X }
C {devices/lab_pin.sym} 10110 -20840 0 1 {name=p3851 lab=_2582_/D }
C {sky130_stdcells/o21a_4.sym} 10030 -20840 0 0 {name=X_1803_ }
C {devices/lab_pin.sym} 9990 -20700 0 0 {name=p3852 lab=_1733_/Y }
C {devices/lab_pin.sym} 10070 -20700 0 1 {name=p3853 lab=_2592_/D }
C {sky130_stdcells/inv_2.sym} 10030 -20700 0 0 {name=X_1734_ }
C {devices/lab_pin.sym} 9970 -20600 0 0 {name=p3854 lab=_1570_/A }
C {devices/lab_pin.sym} 9970 -20560 0 0 {name=p3855 lab=_1664_/Y }
C {devices/lab_pin.sym} 9970 -20520 0 0 {name=p3856 lab=_1660_/A }
C {devices/lab_pin.sym} 10090 -20560 0 1 {name=p3857 lab=_2146_/A }
C {sky130_stdcells/nor3_4.sym} 10030 -20560 0 0 {name=X_1665_ }
C {devices/lab_pin.sym} 9950 -20460 0 0 {name=p3858 lab=_1545_/X }
C {devices/lab_pin.sym} 9950 -20420 0 0 {name=p3859 lab=_1576_/X }
C {devices/lab_pin.sym} 9950 -20380 0 0 {name=p3860 lab=_1588_/Y }
C {devices/lab_pin.sym} 9950 -20340 0 0 {name=p3861 lab=_1593_/Y }
C {devices/lab_pin.sym} 9950 -20310 0 0 {name=p3862 lab=_1595_/X }
C {devices/lab_pin.sym} 10110 -20380 0 1 {name=p3863 lab=_2598_/D }
C {sky130_stdcells/a41oi_4.sym} 10030 -20380 0 0 {name=X_1596_ }
C {devices/lab_pin.sym} 9950 -20240 0 0 {name=p3864 lab=_1534_/X }
C {devices/lab_pin.sym} 9950 -20200 0 0 {name=p3865 lab=_2551_/Q }
C {devices/lab_pin.sym} 9950 -20160 0 0 {name=p3866 lab=_1640_/X }
C {devices/lab_pin.sym} 10110 -20200 0 1 {name=p3867 lab=_2217_/Y }
C {sky130_stdcells/o21ai_4.sym} 10030 -20200 0 0 {name=X_2217_ }
C {devices/lab_pin.sym} 9970 -20080 0 0 {name=p3868 lab=_2078_/X }
C {devices/lab_pin.sym} 9970 -20040 0 0 {name=p3869 lab=_1991_/B }
C {devices/lab_pin.sym} 9970 -20000 0 0 {name=p3870 lab=_1991_/C }
C {devices/lab_pin.sym} 10090 -20040 0 1 {name=p3871 lab=_2084_/C }
C {sky130_stdcells/nand3_4.sym} 10030 -20040 0 0 {name=X_2079_ }
C {devices/lab_pin.sym} 9990 -19900 0 0 {name=p3872 lab=_1613_/Y }
C {devices/lab_pin.sym} 10070 -19900 0 1 {name=p3873 lab=_2148_/X }
C {sky130_stdcells/buf_2.sym} 10030 -19900 0 0 {name=X_2148_ }
C {devices/lab_pin.sym} 9990 -19780 0 0 {name=p3874 lab=_1446_/Y }
C {devices/lab_pin.sym} 10070 -19780 0 1 {name=p3875 lab=_1450_/X }
C {sky130_stdcells/buf_2.sym} 10030 -19780 0 0 {name=X_1450_ }
C {devices/lab_pin.sym} 9950 -19700 0 0 {name=p3876 lab=_1373_/B }
C {devices/lab_pin.sym} 9950 -19660 0 0 {name=p3877 lab=_1379_/X }
C {devices/lab_pin.sym} 9950 -19620 0 0 {name=p3878 lab=_1385_/D }
C {devices/lab_pin.sym} 9950 -19580 0 0 {name=p3879 lab=_1365_/D }
C {devices/lab_pin.sym} 9950 -19550 0 0 {name=p3880 lab=_1275_/X }
C {devices/lab_pin.sym} 10110 -19620 0 1 {name=p3881 lab=_1381_/Y }
C {sky130_stdcells/a41oi_4.sym} 10030 -19620 0 0 {name=X_1381_ }
C {devices/lab_pin.sym} 9990 -19460 0 0 {name=p3882 lab=_1998_/A }
C {devices/lab_pin.sym} 10070 -19460 0 1 {name=p3883 lab=_2002_/X }
C {sky130_stdcells/buf_2.sym} 10030 -19460 0 0 {name=X_2002_ }
C {devices/lab_pin.sym} 9990 -19340 0 0 {name=p3884 lab=_1667_/B }
C {devices/lab_pin.sym} 10070 -19340 0 1 {name=p3885 lab=_1649_/B }
C {sky130_stdcells/inv_2.sym} 10030 -19340 0 0 {name=X_1648_ }
C {devices/lab_pin.sym} 9990 -19220 0 0 {name=p3886 lab=_1428_/B }
C {devices/lab_pin.sym} 10070 -19220 0 1 {name=p3887 lab=_1579_/X }
C {sky130_stdcells/buf_2.sym} 10030 -19220 0 0 {name=X_1579_ }
C {devices/lab_pin.sym} 9950 -19120 0 0 {name=p3888 lab=_1712_/Y }
C {devices/lab_pin.sym} 9950 -19080 0 0 {name=p3889 lab=_1633_/X }
C {devices/lab_pin.sym} 9950 -19040 0 0 {name=p3890 lab=_1716_/Y }
C {devices/lab_pin.sym} 10110 -19080 0 1 {name=p3891 lab=_1717_/Y }
C {sky130_stdcells/a21oi_4.sym} 10030 -19080 0 0 {name=X_1717_ }
C {sky130_stdcells/decap_3.sym} 10030 -18910 0 0 {name=XPHY_12 }
C {sky130_stdcells/decap_3.sym} 10030 -18730 0 0 {name=XPHY_89 }
C {sky130_stdcells/decap_3.sym} 10030 -18550 0 0 {name=XPHY_78 }
C {sky130_stdcells/decap_3.sym} 10030 -18370 0 0 {name=XPHY_67 }
C {sky130_stdcells/decap_3.sym} 10030 -18190 0 0 {name=XPHY_56 }
C {sky130_stdcells/decap_3.sym} 10030 -18010 0 0 {name=XPHY_23 }
C {sky130_stdcells/decap_3.sym} 10030 -17830 0 0 {name=XPHY_34 }
C {sky130_stdcells/decap_3.sym} 10030 -17650 0 0 {name=XPHY_45 }
C {devices/lab_pin.sym} 9940 -17500 0 0 {name=p3892 lab=_2367_/CLK }
C {devices/lab_pin.sym} 9940 -17480 0 0 {name=p3893 lab=_2620_/D }
C {devices/lab_pin.sym} 10120 -17500 0 1 {name=p3894 lab=_2620_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -17490 0 0 {name=X_2620_ }
C {devices/lab_pin.sym} 9940 -17360 0 0 {name=p3895 lab=_2483_/CLK }
C {devices/lab_pin.sym} 9940 -17340 0 0 {name=p3896 lab=_2052_/Y }
C {devices/lab_pin.sym} 10120 -17360 0 1 {name=p3897 lab=_1985_/A }
C {sky130_stdcells/dfxtp_4.sym} 10030 -17350 0 0 {name=X_2482_ }
C {devices/lab_pin.sym} 9940 -17220 0 0 {name=p3898 lab=_2554_/CLK }
C {devices/lab_pin.sym} 9940 -17200 0 0 {name=p3899 lab=_2551_/D }
C {devices/lab_pin.sym} 10120 -17220 0 1 {name=p3900 lab=_2551_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -17210 0 0 {name=X_2551_ }
C {devices/lab_pin.sym} 9950 -17100 0 0 {name=p3901 lab=_1496_/Y }
C {devices/lab_pin.sym} 9950 -17060 0 0 {name=p3902 lab=_1498_/Y }
C {devices/lab_pin.sym} 9950 -17020 0 0 {name=p3903 lab=_1501_/X }
C {devices/lab_pin.sym} 10110 -17060 0 1 {name=p3904 lab=_1502_/Y }
C {sky130_stdcells/a21oi_4.sym} 10030 -17060 0 0 {name=X_1502_ }
C {devices/lab_pin.sym} 9990 -16920 0 0 {name=p3905 lab=_1433_/A }
C {devices/lab_pin.sym} 10070 -16920 0 1 {name=p3906 lab=_1440_/B }
C {sky130_stdcells/buf_2.sym} 10030 -16920 0 0 {name=X_1433_ }
C {devices/lab_pin.sym} 9990 -16800 0 0 {name=p3907 lab=_2620_/Q }
C {devices/lab_pin.sym} 10070 -16800 0 1 {name=p3908 lab=_1383_/C }
C {sky130_stdcells/buf_2.sym} 10030 -16800 0 0 {name=X_1364_ }
C {devices/lab_pin.sym} 9970 -16710 0 0 {name=p3909 lab=_1295_/A }
C {devices/lab_pin.sym} 9970 -16670 0 0 {name=p3910 lab=_1308_/A }
C {devices/lab_pin.sym} 9970 -16630 0 0 {name=p3911 lab=_1299_/A }
C {devices/lab_pin.sym} 9970 -16590 0 0 {name=p3912 lab=_1292_/C }
C {devices/lab_pin.sym} 10090 -16650 0 1 {name=p3913 lab=_1296_/B }
C {sky130_stdcells/nand4_4.sym} 10030 -16650 0 0 {name=X_1295_ }
C {devices/lab_pin.sym} 9990 -16500 0 0 {name=p3914 lab=clkbuf_2_3_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 10070 -16500 0 1 {name=p3915 lab=clkbuf_3_7_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 10030 -16500 0 0 {name=Xclkbuf_2_3_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 9990 -16380 0 0 {name=p3916 lab=_1981_/X }
C {devices/lab_pin.sym} 10070 -16380 0 1 {name=p3917 lab=_2495_/D }
C {sky130_stdcells/inv_2.sym} 10030 -16380 0 0 {name=X_1982_ }
C {devices/lab_pin.sym} 9940 -16260 0 0 {name=p3918 lab=_2496_/CLK }
C {devices/lab_pin.sym} 9940 -16240 0 0 {name=p3919 lab=_1918_/X }
C {devices/lab_pin.sym} 10120 -16260 0 1 {name=p3920 lab=HASH_ADDR[3] }
C {sky130_stdcells/dfxtp_4.sym} 10030 -16250 0 0 {name=X_2534_ }
C {devices/lab_pin.sym} 9940 -16120 0 0 {name=p3921 lab=_2598_/CLK }
C {devices/lab_pin.sym} 9940 -16100 0 0 {name=p3922 lab=_2603_/D }
C {devices/lab_pin.sym} 10120 -16120 0 1 {name=p3923 lab=_2603_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -16110 0 0 {name=X_2603_ }
C {devices/lab_pin.sym} 9940 -15980 0 0 {name=p3924 lab=_2457_/CLK }
C {devices/lab_pin.sym} 9940 -15960 0 0 {name=p3925 lab=_2095_/X }
C {devices/lab_pin.sym} 10120 -15980 0 1 {name=p3926 lab=_2094_/B }
C {sky130_stdcells/dfxtp_4.sym} 10030 -15970 0 0 {name=X_2465_ }
C {devices/lab_pin.sym} 9950 -15860 0 0 {name=p3927 lab=_1413_/Y }
C {devices/lab_pin.sym} 9950 -15820 0 0 {name=p3928 lab=_1419_/C }
C {devices/lab_pin.sym} 9950 -15780 0 0 {name=p3929 lab=_1415_/Y }
C {devices/lab_pin.sym} 10110 -15820 0 1 {name=p3930 lab=_1417_/A }
C {sky130_stdcells/o21ai_4.sym} 10030 -15820 0 0 {name=X_1416_ }
C {devices/lab_pin.sym} 9970 -15700 0 0 {name=p3931 lab=_1344_/X }
C {devices/lab_pin.sym} 9970 -15660 0 0 {name=p3932 lab=_1345_/Y }
C {devices/lab_pin.sym} 9970 -15620 0 0 {name=p3933 lab=_1346_/X }
C {devices/lab_pin.sym} 10090 -15660 0 1 {name=p3934 lab=_1347_/Y }
C {sky130_stdcells/nand3_4.sym} 10030 -15660 0 0 {name=X_1347_ }
C {devices/lab_pin.sym} 9940 -15520 0 0 {name=p3935 lab=_2410_/CLK }
C {devices/lab_pin.sym} 9940 -15500 0 0 {name=p3936 lab=_2320_/X }
C {devices/lab_pin.sym} 10120 -15520 0 1 {name=p3937 lab=_1764_/A }
C {sky130_stdcells/dfxtp_4.sym} 10030 -15510 0 0 {name=X_2396_ }
C {devices/lab_pin.sym} 9970 -15390 0 0 {name=p3938 lab=_1276_/Y }
C {devices/lab_pin.sym} 9970 -15350 0 0 {name=p3939 lab=_1278_/B }
C {devices/lab_pin.sym} 10090 -15370 0 1 {name=p3940 lab=_1279_/A }
C {sky130_stdcells/nand2_4.sym} 10030 -15370 0 0 {name=X_1278_ }
C {devices/lab_pin.sym} 9950 -15260 0 0 {name=p3941 lab=_1199_/Y }
C {devices/lab_pin.sym} 9950 -15220 0 0 {name=p3942 lab=_1187_/X }
C {devices/lab_pin.sym} 9950 -15180 0 0 {name=p3943 lab=_1200_/Y }
C {devices/lab_pin.sym} 10110 -15220 0 1 {name=p3944 lab=_1201_/Y }
C {sky130_stdcells/a21oi_4.sym} 10030 -15220 0 0 {name=X_1201_ }
C {devices/lab_pin.sym} 9950 -15120 0 0 {name=p3945 lab=_2244_/X }
C {devices/lab_pin.sym} 9950 -15080 0 0 {name=p3946 lab=_2127_/Y }
C {devices/lab_pin.sym} 9950 -15040 0 0 {name=p3947 lab=_2247_/X }
C {devices/lab_pin.sym} 9950 -15000 0 0 {name=p3948 lab=_1710_/B }
C {devices/lab_pin.sym} 9950 -14960 0 0 {name=p3949 lab=_2249_/X }
C {devices/lab_pin.sym} 10110 -15040 0 1 {name=p3950 lab=_2433_/D }
C {sky130_stdcells/o32ai_4.sym} 10030 -15040 0 0 {name=X_2250_ }
C {devices/lab_pin.sym} 9970 -14890 0 0 {name=p3951 lab=_2181_/A }
C {devices/lab_pin.sym} 9970 -14850 0 0 {name=p3952 lab=_1771_/Y }
C {devices/lab_pin.sym} 10090 -14870 0 1 {name=p3953 lab=_2181_/Y }
C {sky130_stdcells/nor2_4.sym} 10030 -14870 0 0 {name=X_2181_ }
C {devices/lab_pin.sym} 9970 -14750 0 0 {name=p3954 lab=_1284_/X }
C {devices/lab_pin.sym} 9970 -14710 0 0 {name=p3955 lab=_1965_/B }
C {devices/lab_pin.sym} 10090 -14730 0 1 {name=p3956 lab=_1965_/Y }
C {sky130_stdcells/nor2_4.sym} 10030 -14730 0 0 {name=X_1965_ }
C {devices/lab_pin.sym} 9970 -14610 0 0 {name=p3957 lab=_1896_/A }
C {devices/lab_pin.sym} 9970 -14570 0 0 {name=p3958 lab=_2550_/Q }
C {devices/lab_pin.sym} 10090 -14590 0 1 {name=p3959 lab=_2546_/D }
C {sky130_stdcells/and2_4.sym} 10030 -14590 0 0 {name=X_1896_ }
C {devices/lab_pin.sym} 9940 -14460 0 0 {name=p3960 lab=_2638_/CLK }
C {devices/lab_pin.sym} 9940 -14440 0 0 {name=p3961 lab=_1945_/Y }
C {devices/lab_pin.sym} 10120 -14460 0 1 {name=p3962 lab=_1957_/B }
C {sky130_stdcells/dfxtp_4.sym} 10030 -14450 0 0 {name=X_2517_ }
C {devices/lab_pin.sym} 9940 -14320 0 0 {name=p3963 lab=_2498_/CLK }
C {devices/lab_pin.sym} 9940 -14300 0 0 {name=p3964 lab=_2379_/D }
C {devices/lab_pin.sym} 10120 -14320 0 1 {name=p3965 lab=_2379_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -14310 0 0 {name=X_2379_ }
C {devices/lab_pin.sym} 9940 -14180 0 0 {name=p3966 lab=_2557_/CLK }
C {devices/lab_pin.sym} 9940 -14160 0 0 {name=p3967 lab=_2448_/D }
C {devices/lab_pin.sym} 10120 -14180 0 1 {name=p3968 lab=_2448_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -14170 0 0 {name=X_2448_ }
C {devices/lab_pin.sym} 9990 -14040 0 0 {name=p3969 lab=_1750_/A }
C {devices/lab_pin.sym} 10070 -14040 0 1 {name=p3970 lab=_1751_/B }
C {sky130_stdcells/inv_2.sym} 10030 -14040 0 0 {name=X_1750_ }
C {devices/lab_pin.sym} 9950 -13940 0 0 {name=p3971 lab=_1679_/Y }
C {devices/lab_pin.sym} 9950 -13900 0 0 {name=p3972 lab=_1680_/X }
C {devices/lab_pin.sym} 9950 -13860 0 0 {name=p3973 lab=_1529_/Y }
C {devices/lab_pin.sym} 10110 -13900 0 1 {name=p3974 lab=_1681_/X }
C {sky130_stdcells/o21a_4.sym} 10030 -13900 0 0 {name=X_1681_ }
C {devices/lab_pin.sym} 9950 -13780 0 0 {name=p3975 lab=_2216_/Y }
C {devices/lab_pin.sym} 9950 -13740 0 0 {name=p3976 lab=_2231_/Y }
C {devices/lab_pin.sym} 9950 -13700 0 0 {name=p3977 lab=_2232_/Y }
C {devices/lab_pin.sym} 10110 -13740 0 1 {name=p3978 lab=_2233_/Y }
C {sky130_stdcells/o21ai_4.sym} 10030 -13740 0 0 {name=X_2233_ }
C {devices/lab_pin.sym} 9950 -13620 0 0 {name=p3979 lab=_1611_/A }
C {devices/lab_pin.sym} 9950 -13580 0 0 {name=p3980 lab=_1236_/A }
C {devices/lab_pin.sym} 9950 -13540 0 0 {name=p3981 lab=_1656_/A }
C {devices/lab_pin.sym} 10110 -13580 0 1 {name=p3982 lab=_2164_/X }
C {sky130_stdcells/a21o_4.sym} 10030 -13580 0 0 {name=X_2164_ }
C {devices/lab_pin.sym} 9970 -13460 0 0 {name=p3983 lab=_2304_/A }
C {devices/lab_pin.sym} 9970 -13420 0 0 {name=p3984 lab=_1602_/C }
C {devices/lab_pin.sym} 9970 -13380 0 0 {name=p3985 lab=HASH_LED }
C {devices/lab_pin.sym} 10090 -13420 0 1 {name=p3986 lab=_2302_/Y }
C {sky130_stdcells/nand3_4.sym} 10030 -13420 0 0 {name=X_2302_ }
C {devices/lab_pin.sym} 9970 -13290 0 0 {name=p3987 lab=_1900_/A }
C {devices/lab_pin.sym} 9970 -13250 0 0 {name=p3988 lab=IRQ_OUT_fromClient }
C {devices/lab_pin.sym} 10090 -13270 0 1 {name=p3989 lab=_2095_/X }
C {sky130_stdcells/and2_4.sym} 10030 -13270 0 0 {name=X_2095_ }
C {devices/lab_pin.sym} 9970 -13150 0 0 {name=p3990 lab=_1878_/A }
C {devices/lab_pin.sym} 9970 -13110 0 0 {name=p3991 lab=DATA_FROM_HASH[1] }
C {devices/lab_pin.sym} 10090 -13130 0 1 {name=p3992 lab=_2560_/D }
C {sky130_stdcells/and2_4.sym} 10030 -13130 0 0 {name=X_1879_ }
C {devices/lab_pin.sym} 9990 -13000 0 0 {name=p3993 lab=_1948_/A }
C {devices/lab_pin.sym} 10070 -13000 0 1 {name=p3994 lab=_1948_/Y }
C {sky130_stdcells/inv_2.sym} 10030 -13000 0 0 {name=X_1948_ }
C {devices/lab_pin.sym} 9950 -12900 0 0 {name=p3995 lab=_1730_/X }
C {devices/lab_pin.sym} 9950 -12860 0 0 {name=p3996 lab=_1731_/Y }
C {devices/lab_pin.sym} 9950 -12820 0 0 {name=p3997 lab=_1732_/Y }
C {devices/lab_pin.sym} 10110 -12860 0 1 {name=p3998 lab=_1733_/Y }
C {sky130_stdcells/o21ai_4.sym} 10030 -12860 0 0 {name=X_1733_ }
C {devices/lab_pin.sym} 9950 -12740 0 0 {name=p3999 lab=_2591_/Q }
C {devices/lab_pin.sym} 9950 -12700 0 0 {name=p4000 lab=_1503_/A }
C {devices/lab_pin.sym} 9950 -12660 0 0 {name=p4001 lab=_1799_/X }
C {devices/lab_pin.sym} 10110 -12700 0 1 {name=p4002 lab=_1802_/X }
C {sky130_stdcells/o21a_4.sym} 10030 -12700 0 0 {name=X_1802_ }
C {devices/lab_pin.sym} 9970 -12580 0 0 {name=p4003 lab=_1664_/A }
C {devices/lab_pin.sym} 9970 -12540 0 0 {name=p4004 lab=_1579_/X }
C {devices/lab_pin.sym} 9970 -12500 0 0 {name=p4005 lab=_1428_/C }
C {devices/lab_pin.sym} 10090 -12540 0 1 {name=p4006 lab=_1664_/Y }
C {sky130_stdcells/nand3_4.sym} 10030 -12540 0 0 {name=X_1664_ }
C {devices/lab_pin.sym} 9950 -12420 0 0 {name=p4007 lab=_1549_/A }
C {devices/lab_pin.sym} 9950 -12380 0 0 {name=p4008 lab=_1594_/X }
C {devices/lab_pin.sym} 9950 -12340 0 0 {name=p4009 lab=_1781_/A }
C {devices/lab_pin.sym} 10110 -12380 0 1 {name=p4010 lab=_1595_/X }
C {sky130_stdcells/a21o_4.sym} 10030 -12380 0 0 {name=X_1595_ }
C {devices/lab_pin.sym} 9950 -12280 0 0 {name=p4011 lab=_2616_/Q }
C {devices/lab_pin.sym} 9950 -12240 0 0 {name=p4012 lab=_1571_/A }
C {devices/lab_pin.sym} 9950 -12200 0 0 {name=p4013 lab=_1661_/C }
C {devices/lab_pin.sym} 9950 -12160 0 0 {name=p4014 lab=_1661_/D }
C {devices/lab_pin.sym} 9950 -12120 0 0 {name=p4015 lab=_2146_/Y }
C {devices/lab_pin.sym} 10110 -12200 0 1 {name=p4016 lab=_2147_/Y }
C {sky130_stdcells/o41ai_4.sym} 10030 -12200 0 0 {name=X_2147_ }
C {devices/lab_pin.sym} 9950 -12080 0 0 {name=p4017 lab=_1409_/C }
C {devices/lab_pin.sym} 9950 -12040 0 0 {name=p4018 lab=_1860_/B }
C {devices/lab_pin.sym} 9950 -12000 0 0 {name=p4019 lab=_1661_/C }
C {devices/lab_pin.sym} 9950 -11960 0 0 {name=p4020 lab=_1661_/D }
C {devices/lab_pin.sym} 9950 -11920 0 0 {name=p4021 lab=_2146_/Y }
C {devices/lab_pin.sym} 10110 -12000 0 1 {name=p4022 lab=_2216_/Y }
C {sky130_stdcells/o41ai_4.sym} 10030 -12000 0 0 {name=X_2216_ }
C {devices/lab_pin.sym} 9990 -11840 0 0 {name=p4023 lab=_1991_/A }
C {devices/lab_pin.sym} 10070 -11840 0 1 {name=p4024 lab=_2078_/X }
C {sky130_stdcells/buf_2.sym} 10030 -11840 0 0 {name=X_2078_ }
C {devices/lab_pin.sym} 9990 -11720 0 0 {name=p4025 lab=_1383_/C }
C {devices/lab_pin.sym} 10070 -11720 0 1 {name=p4026 lab=_1385_/D }
C {sky130_stdcells/buf_2.sym} 10030 -11720 0 0 {name=X_1380_ }
C {devices/lab_pin.sym} 9970 -11610 0 0 {name=p4027 lab=_2010_/C }
C {devices/lab_pin.sym} 9970 -11570 0 0 {name=p4028 lab=_2001_/B }
C {devices/lab_pin.sym} 10090 -11590 0 1 {name=p4029 lab=_2001_/Y }
C {sky130_stdcells/nand2_4.sym} 10030 -11590 0 0 {name=X_2001_ }
C {devices/lab_pin.sym} 9970 -11470 0 0 {name=p4030 lab=_1715_/X }
C {devices/lab_pin.sym} 9970 -11430 0 0 {name=p4031 lab=_1534_/A }
C {devices/lab_pin.sym} 10090 -11450 0 1 {name=p4032 lab=_1716_/Y }
C {sky130_stdcells/nand2_4.sym} 10030 -11450 0 0 {name=X_1716_ }
C {devices/lab_pin.sym} 9970 -11330 0 0 {name=p4033 lab=_1667_/C }
C {devices/lab_pin.sym} 9970 -11290 0 0 {name=p4034 lab=_1667_/D }
C {devices/lab_pin.sym} 10090 -11310 0 1 {name=p4035 lab=_1659_/A }
C {sky130_stdcells/nand2_4.sym} 10030 -11310 0 0 {name=X_1647_ }
C {devices/lab_pin.sym} 9950 -11200 0 0 {name=p4036 lab=_1577_/X }
C {devices/lab_pin.sym} 9950 -11160 0 0 {name=p4037 lab=_1460_/X }
C {devices/lab_pin.sym} 9950 -11120 0 0 {name=p4038 lab=_1503_/A }
C {devices/lab_pin.sym} 10110 -11160 0 1 {name=p4039 lab=_1578_/Y }
C {sky130_stdcells/o21ai_4.sym} 10030 -11160 0 0 {name=X_1578_ }
C {sky130_stdcells/decap_3.sym} 10030 -10990 0 0 {name=XPHY_13 }
C {sky130_stdcells/decap_3.sym} 10030 -10810 0 0 {name=XPHY_24 }
C {sky130_stdcells/decap_3.sym} 10030 -10630 0 0 {name=XPHY_35 }
C {sky130_stdcells/decap_3.sym} 10030 -10450 0 0 {name=XPHY_46 }
C {sky130_stdcells/decap_3.sym} 10030 -10270 0 0 {name=XPHY_79 }
C {sky130_stdcells/decap_3.sym} 10030 -10090 0 0 {name=XPHY_68 }
C {sky130_stdcells/decap_3.sym} 10030 -9910 0 0 {name=XPHY_57 }
C {devices/lab_pin.sym} 9940 -9760 0 0 {name=p4040 lab=_2550_/CLK }
C {devices/lab_pin.sym} 9940 -9740 0 0 {name=p4041 lab=_2550_/D }
C {devices/lab_pin.sym} 10120 -9760 0 1 {name=p4042 lab=_2550_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -9750 0 0 {name=X_2550_ }
C {devices/lab_pin.sym} 9940 -9620 0 0 {name=p4043 lab=_2483_/CLK }
C {devices/lab_pin.sym} 9940 -9600 0 0 {name=p4044 lab=_2057_/X }
C {devices/lab_pin.sym} 10120 -9620 0 1 {name=p4045 lab=_1993_/D }
C {sky130_stdcells/dfxtp_4.sym} 10030 -9610 0 0 {name=X_2481_ }
C {devices/lab_pin.sym} 9970 -9500 0 0 {name=p4046 lab=_1397_/B }
C {devices/lab_pin.sym} 9970 -9460 0 0 {name=p4047 lab=_1233_/C }
C {devices/lab_pin.sym} 9970 -9420 0 0 {name=p4048 lab=_1397_/C }
C {devices/lab_pin.sym} 10090 -9460 0 1 {name=p4049 lab=_1383_/A }
C {sky130_stdcells/nor3_4.sym} 10030 -9460 0 0 {name=X_1363_ }
C {devices/lab_pin.sym} 9950 -9340 0 0 {name=p4050 lab=_1450_/X }
C {devices/lab_pin.sym} 9950 -9300 0 0 {name=p4051 lab=_1499_/Y }
C {devices/lab_pin.sym} 9950 -9260 0 0 {name=p4052 lab=_1500_/X }
C {devices/lab_pin.sym} 10110 -9300 0 1 {name=p4053 lab=_1501_/X }
C {sky130_stdcells/a21o_4.sym} 10030 -9300 0 0 {name=X_1501_ }
C {devices/lab_pin.sym} 9970 -9190 0 0 {name=p4054 lab=_1429_/Y }
C {devices/lab_pin.sym} 9970 -9150 0 0 {name=p4055 lab=_1701_/A }
C {devices/lab_pin.sym} 9970 -9110 0 0 {name=p4056 lab=_1466_/A }
C {devices/lab_pin.sym} 9970 -9070 0 0 {name=p4057 lab=_2602_/Q }
C {devices/lab_pin.sym} 10090 -9130 0 1 {name=p4058 lab=_1433_/A }
C {sky130_stdcells/and4_4.sym} 10030 -9130 0 0 {name=X_1432_ }
C {devices/lab_pin.sym} 9950 -9000 0 0 {name=p4059 lab=_1301_/A }
C {devices/lab_pin.sym} 9950 -8960 0 0 {name=p4060 lab=_1293_/Y }
C {devices/lab_pin.sym} 9950 -8920 0 0 {name=p4061 lab=_1275_/X }
C {devices/lab_pin.sym} 10110 -8960 0 1 {name=p4062 lab=_1296_/A }
C {sky130_stdcells/a21oi_4.sym} 10030 -8960 0 0 {name=X_1294_ }
C {devices/lab_pin.sym} 9970 -8840 0 0 {name=p4063 lab=_1979_/A }
C {devices/lab_pin.sym} 9970 -8800 0 0 {name=p4064 lab=_1976_/A }
C {devices/lab_pin.sym} 9970 -8760 0 0 {name=p4065 lab=_1976_/B }
C {devices/lab_pin.sym} 10090 -8800 0 1 {name=p4066 lab=_1981_/X }
C {sky130_stdcells/or3_4.sym} 10030 -8800 0 0 {name=X_1981_ }
C {devices/lab_pin.sym} 9940 -8660 0 0 {name=p4067 lab=_2388_/CLK }
C {devices/lab_pin.sym} 9940 -8640 0 0 {name=p4068 lab=_1551_/Y }
C {devices/lab_pin.sym} 10120 -8660 0 1 {name=p4069 lab=_2602_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -8650 0 0 {name=X_2602_ }
C {devices/lab_pin.sym} 9940 -8520 0 0 {name=p4070 lab=_2519_/CLK }
C {devices/lab_pin.sym} 9940 -8500 0 0 {name=p4071 lab=_2533_/D }
C {devices/lab_pin.sym} 10120 -8520 0 1 {name=p4072 lab=HASH_ADDR[2] }
C {sky130_stdcells/dfxtp_4.sym} 10030 -8510 0 0 {name=X_2533_ }
C {devices/lab_pin.sym} 9940 -8380 0 0 {name=p4073 lab=_2457_/CLK }
C {devices/lab_pin.sym} 9940 -8360 0 0 {name=p4074 lab=_2097_/X }
C {devices/lab_pin.sym} 10120 -8380 0 1 {name=p4075 lab=_2464_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -8370 0 0 {name=X_2464_ }
C {devices/lab_pin.sym} 9950 -8260 0 0 {name=p4076 lab=_1419_/C }
C {devices/lab_pin.sym} 9950 -8220 0 0 {name=p4077 lab=_1413_/Y }
C {devices/lab_pin.sym} 9950 -8180 0 0 {name=p4078 lab=_1283_/X }
C {devices/lab_pin.sym} 10110 -8220 0 1 {name=p4079 lab=_1415_/Y }
C {sky130_stdcells/a21oi_4.sym} 10030 -8220 0 0 {name=X_1415_ }
C {devices/lab_pin.sym} 9990 -8080 0 0 {name=p4080 lab=_1270_/A }
C {devices/lab_pin.sym} 10070 -8080 0 1 {name=p4081 lab=_1346_/X }
C {sky130_stdcells/buf_2.sym} 10030 -8080 0 0 {name=X_1346_ }
C {devices/lab_pin.sym} 9940 -7960 0 0 {name=p4082 lab=_2410_/CLK }
C {devices/lab_pin.sym} 9940 -7940 0 0 {name=p4083 lab=_2395_/D }
C {devices/lab_pin.sym} 10120 -7960 0 1 {name=p4084 lab=_1767_/B }
C {sky130_stdcells/dfxtp_4.sym} 10030 -7950 0 0 {name=X_2395_ }
C {devices/lab_pin.sym} 9970 -7850 0 0 {name=p4085 lab=_1277_/A }
C {devices/lab_pin.sym} 9970 -7810 0 0 {name=p4086 lab=_1277_/B }
C {devices/lab_pin.sym} 9970 -7770 0 0 {name=p4087 lab=_2641_/Q }
C {devices/lab_pin.sym} 9970 -7730 0 0 {name=p4088 lab=_1277_/D }
C {devices/lab_pin.sym} 10090 -7790 0 1 {name=p4089 lab=_1278_/B }
C {sky130_stdcells/nand4_4.sym} 10030 -7790 0 0 {name=X_1277_ }
C {devices/lab_pin.sym} 9950 -7660 0 0 {name=p4090 lab=_1762_/B }
C {devices/lab_pin.sym} 9950 -7620 0 0 {name=p4091 lab=_1216_/B }
C {devices/lab_pin.sym} 9950 -7580 0 0 {name=p4092 lab=_1191_/X }
C {devices/lab_pin.sym} 10110 -7620 0 1 {name=p4093 lab=_1200_/Y }
C {sky130_stdcells/o21ai_4.sym} 10030 -7620 0 0 {name=X_1200_ }
C {devices/lab_pin.sym} 9950 -7500 0 0 {name=p4094 lab=_2176_/Y }
C {devices/lab_pin.sym} 9950 -7460 0 0 {name=p4095 lab=_2179_/Y }
C {devices/lab_pin.sym} 9950 -7420 0 0 {name=p4096 lab=_2449_/Q }
C {devices/lab_pin.sym} 10110 -7460 0 1 {name=p4097 lab=_2180_/X }
C {sky130_stdcells/a21o_4.sym} 10030 -7460 0 0 {name=X_2180_ }
C {devices/lab_pin.sym} 9970 -7330 0 0 {name=p4098 lab=_1896_/A }
C {devices/lab_pin.sym} 9970 -7290 0 0 {name=p4099 lab=DATA_AVAILABLE[0] }
C {devices/lab_pin.sym} 10090 -7310 0 1 {name=p4100 lab=_2547_/D }
C {sky130_stdcells/and2_4.sym} 10030 -7310 0 0 {name=X_1895_ }
C {devices/lab_pin.sym} 9990 -7180 0 0 {name=p4101 lab=clkbuf_3_1_0_m1_clk_local/A }
C {devices/lab_pin.sym} 10070 -7180 0 1 {name=p4102 lab=clkbuf_4_1_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 10030 -7180 0 0 {name=Xclkbuf_3_0_0_m1_clk_local }
C {devices/lab_pin.sym} 9990 -7060 0 0 {name=p4103 lab=_1964_/A }
C {devices/lab_pin.sym} 10070 -7060 0 1 {name=p4104 lab=_1965_/B }
C {sky130_stdcells/inv_2.sym} 10030 -7060 0 0 {name=X_1964_ }
C {devices/lab_pin.sym} 9940 -6940 0 0 {name=p4105 lab=_2557_/CLK }
C {devices/lab_pin.sym} 9940 -6920 0 0 {name=p4106 lab=_2117_/Y }
C {devices/lab_pin.sym} 10120 -6940 0 1 {name=p4107 lab=_2447_/Q }
C {sky130_stdcells/dfxtp_4.sym} 10030 -6930 0 0 {name=X_2447_ }
C {devices/lab_pin.sym} 9940 -6800 0 0 {name=p4108 lab=_2638_/CLK }
C {devices/lab_pin.sym} 9940 -6780 0 0 {name=p4109 lab=_1947_/Y }
C {devices/lab_pin.sym} 10120 -6800 0 1 {name=p4110 lab=_1958_/B }
C {sky130_stdcells/dfxtp_4.sym} 10030 -6790 0 0 {name=X_2516_ }
C {devices/lab_pin.sym} 9940 -6660 0 0 {name=p4111 lab=_2498_/CLK }
C {devices/lab_pin.sym} 9940 -6640 0 0 {name=p4112 lab=_2377_/Q }
C {devices/lab_pin.sym} 10120 -6660 0 1 {name=p4113 lab=_2379_/D }
C {sky130_stdcells/dfxtp_4.sym} 10030 -6650 0 0 {name=X_2378_ }
C {devices/lab_pin.sym} 9990 -6520 0 0 {name=p4114 lab=_2629_/Q }
C {devices/lab_pin.sym} 10070 -6520 0 1 {name=p4115 lab=_1329_/X }
C {sky130_stdcells/buf_2.sym} 10030 -6520 0 0 {name=X_1329_ }
C {devices/lab_pin.sym} 9970 -6410 0 0 {name=p4116 lab=_1185_/A }
C {devices/lab_pin.sym} 9970 -6370 0 0 {name=p4117 lab=_1680_/B }
C {devices/lab_pin.sym} 10090 -6390 0 1 {name=p4118 lab=_1680_/X }
C {sky130_stdcells/or2_4.sym} 10030 -6390 0 0 {name=X_1680_ }
C {devices/lab_pin.sym} 9950 -6280 0 0 {name=p4119 lab=_1490_/Y }
C {devices/lab_pin.sym} 9950 -6240 0 0 {name=p4120 lab=_2291_/X }
C {devices/lab_pin.sym} 9950 -6200 0 0 {name=p4121 lab=_2300_/Y }
C {devices/lab_pin.sym} 10110 -6240 0 1 {name=p4122 lab=_2407_/D }
C {sky130_stdcells/o21ai_4.sym} 10030 -6240 0 0 {name=X_2301_ }
C {devices/lab_pin.sym} 9950 -6120 0 0 {name=p4123 lab=THREAD_COUNT[0] }
C {devices/lab_pin.sym} 9950 -6080 0 0 {name=p4124 lab=_2166_/A }
C {devices/lab_pin.sym} 9950 -6040 0 0 {name=p4125 lab=_2168_/Y }
C {devices/lab_pin.sym} 10110 -6080 0 1 {name=p4126 lab=_2232_/Y }
C {sky130_stdcells/a21boi_4.sym} 10030 -6080 0 0 {name=X_2232_ }
C {devices/lab_pin.sym} 9950 -5960 0 0 {name=p4127 lab=_1335_/A }
C {devices/lab_pin.sym} 9950 -5920 0 0 {name=p4128 lab=_1646_/X }
C {devices/lab_pin.sym} 9950 -5880 0 0 {name=p4129 lab=_1741_/Y }
C {devices/lab_pin.sym} 10110 -5920 0 1 {name=p4130 lab=_2163_/X }
C {sky130_stdcells/o21a_4.sym} 10030 -5920 0 0 {name=X_2163_ }
C {devices/lab_pin.sym} 9970 -5790 0 0 {name=p4131 lab=_1900_/A }
C {devices/lab_pin.sym} 9970 -5750 0 0 {name=p4132 lab=_2094_/B }
C {devices/lab_pin.sym} 10090 -5770 0 1 {name=p4133 lab=_2094_/X }
C {sky130_stdcells/and2_4.sym} 10030 -5770 0 0 {name=X_2094_ }
C {devices/lab_pin.sym} 9970 -5650 0 0 {name=p4134 lab=_1878_/A }
C {devices/lab_pin.sym} 9970 -5610 0 0 {name=p4135 lab=DATA_FROM_HASH[2] }
C {devices/lab_pin.sym} 10090 -5630 0 1 {name=p4136 lab=_2561_/D }
C {sky130_stdcells/and2_4.sym} 10030 -5630 0 0 {name=X_1878_ }
C {devices/lab_pin.sym} 9970 -5510 0 0 {name=p4137 lab=_1947_/A }
C {devices/lab_pin.sym} 9970 -5470 0 0 {name=p4138 lab=_1947_/B }
C {devices/lab_pin.sym} 10090 -5490 0 1 {name=p4139 lab=_1947_/Y }
C {sky130_stdcells/nor2_4.sym} 10030 -5490 0 0 {name=X_1947_ }
C {devices/lab_pin.sym} 9950 -5380 0 0 {name=p4140 lab=_1730_/X }
C {devices/lab_pin.sym} 9950 -5340 0 0 {name=p4141 lab=_1739_/A }
C {devices/lab_pin.sym} 9950 -5300 0 0 {name=p4142 lab=_1781_/A }
C {devices/lab_pin.sym} 10110 -5340 0 1 {name=p4143 lab=_1732_/Y }
C {sky130_stdcells/a21oi_4.sym} 10030 -5340 0 0 {name=X_1732_ }
C {devices/lab_pin.sym} 9990 -5200 0 0 {name=p4144 lab=_1662_/Y }
C {devices/lab_pin.sym} 10070 -5200 0 1 {name=p4145 lab=_1739_/A }
C {sky130_stdcells/buf_2.sym} 10030 -5200 0 0 {name=X_1663_ }
C {devices/lab_pin.sym} 9950 -5100 0 0 {name=p4146 lab=_1786_/Y }
C {devices/lab_pin.sym} 9950 -5060 0 0 {name=p4147 lab=_2575_/Q }
C {devices/lab_pin.sym} 9950 -5020 0 0 {name=p4148 lab=_1800_/X }
C {devices/lab_pin.sym} 10110 -5060 0 1 {name=p4149 lab=_2583_/D }
C {sky130_stdcells/o21a_4.sym} 10030 -5060 0 0 {name=X_1801_ }
C {devices/lab_pin.sym} 9990 -4920 0 0 {name=p4150 lab=_1590_/B }
C {devices/lab_pin.sym} 10070 -4920 0 1 {name=p4151 lab=_1594_/X }
C {sky130_stdcells/buf_2.sym} 10030 -4920 0 0 {name=X_1594_ }
C {devices/lab_pin.sym} 9990 -4800 0 0 {name=p4152 lab=_2146_/A }
C {devices/lab_pin.sym} 10070 -4800 0 1 {name=p4153 lab=_2146_/Y }
C {sky130_stdcells/inv_2.sym} 10030 -4800 0 0 {name=X_2146_ }
C {devices/lab_pin.sym} 9950 -4700 0 0 {name=p4154 lab=_2071_/Y }
C {devices/lab_pin.sym} 9950 -4660 0 0 {name=p4155 lab=_2060_/B }
C {devices/lab_pin.sym} 9950 -4620 0 0 {name=p4156 lab=_2076_/Y }
C {devices/lab_pin.sym} 10110 -4660 0 1 {name=p4157 lab=_2475_/D }
C {sky130_stdcells/a21oi_4.sym} 10030 -4660 0 0 {name=X_2077_ }
C {devices/lab_pin.sym} 9950 -4540 0 0 {name=p4158 lab=_1726_/A }
C {devices/lab_pin.sym} 9950 -4500 0 0 {name=p4159 lab=_2213_/Y }
C {devices/lab_pin.sym} 9950 -4460 0 0 {name=p4160 lab=_2214_/Y }
C {devices/lab_pin.sym} 10110 -4500 0 1 {name=p4161 lab=_2215_/Y }
C {sky130_stdcells/o21ai_4.sym} 10030 -4500 0 0 {name=X_2215_ }
C {devices/lab_pin.sym} 9990 -4360 0 0 {name=p4162 lab=CLK_LED }
C {devices/lab_pin.sym} 10070 -4360 0 1 {name=p4163 lab=_2001_/B }
C {sky130_stdcells/inv_2.sym} 10030 -4360 0 0 {name=X_2000_ }
C {devices/lab_pin.sym} 9990 -4240 0 0 {name=p4164 lab=clkbuf_2_1_0_addressalyzerBlock.SPI_CLK/X }
C {devices/lab_pin.sym} 10070 -4240 0 1 {name=p4165 lab=clkbuf_4_7_0_addressalyzerBlock.SPI_CLK/A }
C {sky130_stdcells/clkbuf_1.sym} 10030 -4240 0 0 {name=Xclkbuf_3_3_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 9990 -4120 0 0 {name=p4166 lab=_1646_/A }
C {devices/lab_pin.sym} 10070 -4120 0 1 {name=p4167 lab=_1646_/X }
C {sky130_stdcells/buf_2.sym} 10030 -4120 0 0 {name=X_1646_ }
C {devices/lab_pin.sym} 9990 -4000 0 0 {name=p4168 lab=clkbuf_4_9_0_m1_clk_local/A }
C {devices/lab_pin.sym} 10070 -4000 0 1 {name=p4169 lab=_2370_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 10030 -4000 0 0 {name=Xclkbuf_4_9_0_m1_clk_local }
C {devices/lab_pin.sym} 9950 -3910 0 0 {name=p4170 lab=_2445_/Q }
C {devices/lab_pin.sym} 9950 -3870 0 0 {name=p4171 lab=_1703_/X }
C {devices/lab_pin.sym} 9950 -3830 0 0 {name=p4172 lab=_1632_/Y }
C {devices/lab_pin.sym} 9950 -3790 0 0 {name=p4173 lab=_1714_/Y }
C {devices/lab_pin.sym} 10110 -3850 0 1 {name=p4174 lab=_1715_/X }
C {sky130_stdcells/a211o_4.sym} 10030 -3850 0 0 {name=X_1715_ }
C {devices/lab_pin.sym} 9990 -3700 0 0 {name=p4175 lab=_1443_/A }
C {devices/lab_pin.sym} 10070 -3700 0 1 {name=p4176 lab=_1577_/X }
C {sky130_stdcells/buf_2.sym} 10030 -3700 0 0 {name=X_1577_ }
C {sky130_stdcells/decap_3.sym} 10030 -3550 0 0 {name=XPHY_69 }
C {sky130_stdcells/decap_3.sym} 10030 -3370 0 0 {name=XPHY_58 }
C {sky130_stdcells/decap_3.sym} 10030 -3190 0 0 {name=XPHY_47 }
C {sky130_stdcells/decap_3.sym} 10030 -3010 0 0 {name=XPHY_14 }
C {devices/lab_pin.sym} 9950 -2880 0 0 {name=p4177 lab=_2120_/X }
C {devices/lab_pin.sym} 9950 -2840 0 0 {name=p4178 lab=_2127_/Y }
C {devices/lab_pin.sym} 9950 -2800 0 0 {name=p4179 lab=_2128_/Y }
C {devices/lab_pin.sym} 10110 -2840 0 1 {name=p4180 lab=_2445_/D }
C {sky130_stdcells/o21ai_4.sym} 10030 -2840 0 0 {name=X_2129_ }
C {sky130_stdcells/decap_3.sym} 10030 -2670 0 0 {name=XPHY_25 }
C {sky130_stdcells/decap_3.sym} 10030 -2490 0 0 {name=XPHY_36 }
C {devices/lab_pin.sym} 9940 -2340 0 0 {name=p4181 lab=_2483_/CLK }
C {devices/lab_pin.sym} 9940 -2320 0 0 {name=p4182 lab=_2480_/D }
C {devices/lab_pin.sym} 10120 -2340 0 1 {name=p4183 lab=_1993_/C }
C {sky130_stdcells/dfxtp_4.sym} 10030 -2330 0 0 {name=X_2480_ }
C {devices/lab_pin.sym} 9990 -2200 0 0 {name=p4184 lab=_1221_/A }
C {devices/lab_pin.sym} 10070 -2200 0 1 {name=p4185 lab=_1500_/X }
C {sky130_stdcells/buf_2.sym} 10030 -2200 0 0 {name=X_1500_ }
C {devices/lab_pin.sym} 9950 -2100 0 0 {name=p4186 lab=_1367_/A }
C {devices/lab_pin.sym} 9950 -2060 0 0 {name=p4187 lab=_1361_/Y }
C {devices/lab_pin.sym} 9950 -2020 0 0 {name=p4188 lab=_1306_/X }
C {devices/lab_pin.sym} 10110 -2060 0 1 {name=p4189 lab=_1362_/X }
C {sky130_stdcells/o21a_4.sym} 10030 -2060 0 0 {name=X_1362_ }
C {devices/lab_pin.sym} 9990 -1920 0 0 {name=p4190 lab=_1295_/A }
C {devices/lab_pin.sym} 10070 -1920 0 1 {name=p4191 lab=_1293_/Y }
C {sky130_stdcells/inv_2.sym} 10030 -1920 0 0 {name=X_1293_ }
C {devices/lab_pin.sym} 9990 -1800 0 0 {name=p4192 lab=_2603_/Q }
C {devices/lab_pin.sym} 10070 -1800 0 1 {name=p4193 lab=_1466_/A }
C {sky130_stdcells/buf_2.sym} 10030 -1800 0 0 {name=X_1431_ }
C {devices/lab_pin.sym} 9950 -1700 0 0 {name=p4194 lab=_1621_/X }
C {devices/lab_pin.sym} 9950 -1660 0 0 {name=p4195 lab=_1627_/Y }
C {devices/lab_pin.sym} 9950 -1620 0 0 {name=p4196 lab=_1628_/X }
C {devices/lab_pin.sym} 10110 -1660 0 1 {name=p4197 lab=_1629_/X }
C {sky130_stdcells/a21o_4.sym} 10030 -1660 0 0 {name=X_1629_ }
C {devices/lab_pin.sym} 5310 -21940 0 0 {name=p4198 lab=_1980_/A }
C {devices/lab_pin.sym} 5310 -21900 0 0 {name=p4199 lab=_1980_/B }
C {devices/lab_pin.sym} 5310 -21860 0 0 {name=p4200 lab=_1979_/X }
C {devices/lab_pin.sym} 5430 -21900 0 1 {name=p4201 lab=_2496_/D }
C {sky130_stdcells/and3_4.sym} 5370 -21900 0 0 {name=X_1980_ }
C {devices/lab_pin.sym} 5280 -21760 0 0 {name=p4202 lab=_2496_/CLK }
C {devices/lab_pin.sym} 5280 -21740 0 0 {name=p4203 lab=_1920_/X }
C {devices/lab_pin.sym} 5460 -21760 0 1 {name=p4204 lab=HASH_ADDR[1] }
C {sky130_stdcells/dfxtp_4.sym} 5370 -21750 0 0 {name=X_2532_ }
C {devices/lab_pin.sym} 5280 -21620 0 0 {name=p4205 lab=_2570_/CLK }
C {devices/lab_pin.sym} 5280 -21600 0 0 {name=p4206 lab=_2099_/X }
C {devices/lab_pin.sym} 5460 -21620 0 1 {name=p4207 lab=_2463_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -21610 0 0 {name=X_2463_ }
C {devices/lab_pin.sym} 5280 -21480 0 0 {name=p4208 lab=_2388_/CLK }
C {devices/lab_pin.sym} 5280 -21460 0 0 {name=p4209 lab=_1557_/X }
C {devices/lab_pin.sym} 5460 -21480 0 1 {name=p4210 lab=_1608_/B }
C {sky130_stdcells/dfxtp_4.sym} 5370 -21470 0 0 {name=X_2601_ }
C {devices/lab_pin.sym} 5330 -21340 0 0 {name=p4211 lab=_1333_/Y }
C {devices/lab_pin.sym} 5410 -21340 0 1 {name=p4212 lab=_1345_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -21340 0 0 {name=X_1345_ }
C {devices/lab_pin.sym} 5310 -21230 0 0 {name=p4213 lab=_1409_/A }
C {devices/lab_pin.sym} 5310 -21190 0 0 {name=p4214 lab=_1409_/C }
C {devices/lab_pin.sym} 5430 -21210 0 1 {name=p4215 lab=_1419_/C }
C {sky130_stdcells/nand2_4.sym} 5370 -21210 0 0 {name=X_1414_ }
C {devices/lab_pin.sym} 5280 -21080 0 0 {name=p4216 lab=_2590_/CLK }
C {devices/lab_pin.sym} 5280 -21060 0 0 {name=p4217 lab=_2325_/X }
C {devices/lab_pin.sym} 5460 -21080 0 1 {name=p4218 lab=_1728_/C }
C {sky130_stdcells/dfxtp_4.sym} 5370 -21070 0 0 {name=X_2394_ }
C {devices/lab_pin.sym} 5290 -20960 0 0 {name=p4219 lab=_1282_/C }
C {devices/lab_pin.sym} 5290 -20920 0 0 {name=p4220 lab=_1854_/A }
C {devices/lab_pin.sym} 5290 -20880 0 0 {name=p4221 lab=_1275_/X }
C {devices/lab_pin.sym} 5450 -20920 0 1 {name=p4222 lab=_1276_/Y }
C {sky130_stdcells/a21oi_4.sym} 5370 -20920 0 0 {name=X_1276_ }
C {devices/lab_pin.sym} 5310 -20790 0 0 {name=p4223 lab=_1896_/A }
C {devices/lab_pin.sym} 5310 -20750 0 0 {name=p4224 lab=DATA_AVAILABLE[1] }
C {devices/lab_pin.sym} 5430 -20770 0 1 {name=p4225 lab=_1894_/X }
C {sky130_stdcells/and2_4.sym} 5370 -20770 0 0 {name=X_1894_ }
C {devices/lab_pin.sym} 5310 -20650 0 0 {name=p4226 lab=_1947_/A }
C {devices/lab_pin.sym} 5310 -20610 0 0 {name=p4227 lab=_1963_/B }
C {devices/lab_pin.sym} 5430 -20630 0 1 {name=p4228 lab=_1963_/Y }
C {sky130_stdcells/nor2_4.sym} 5370 -20630 0 0 {name=X_1963_ }
C {devices/lab_pin.sym} 5280 -20500 0 0 {name=p4229 lab=_2410_/CLK }
C {devices/lab_pin.sym} 5280 -20480 0 0 {name=p4230 lab=_2446_/D }
C {devices/lab_pin.sym} 5460 -20500 0 1 {name=p4231 lab=_2125_/C }
C {sky130_stdcells/dfxtp_4.sym} 5370 -20490 0 0 {name=X_2446_ }
C {devices/lab_pin.sym} 5280 -20360 0 0 {name=p4232 lab=_2638_/CLK }
C {devices/lab_pin.sym} 5280 -20340 0 0 {name=p4233 lab=_1949_/Y }
C {devices/lab_pin.sym} 5460 -20360 0 1 {name=p4234 lab=_2515_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -20350 0 0 {name=X_2515_ }
C {devices/lab_pin.sym} 5280 -20220 0 0 {name=p4235 lab=_2498_/CLK }
C {devices/lab_pin.sym} 5280 -20200 0 0 {name=p4236 lab=_2377_/D }
C {devices/lab_pin.sym} 5460 -20220 0 1 {name=p4237 lab=_2377_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -20210 0 0 {name=X_2377_ }
C {devices/lab_pin.sym} 5330 -20080 0 0 {name=p4238 lab=_1242_/B }
C {devices/lab_pin.sym} 5410 -20080 0 1 {name=p4239 lab=_1335_/C }
C {sky130_stdcells/buf_2.sym} 5370 -20080 0 0 {name=X_1328_ }
C {devices/lab_pin.sym} 5330 -19960 0 0 {name=p4240 lab=_1226_/Y }
C {devices/lab_pin.sym} 5410 -19960 0 1 {name=p4241 lab=_1292_/C }
C {sky130_stdcells/inv_2.sym} 5370 -19960 0 0 {name=X_1259_ }
C {devices/lab_pin.sym} 5290 -19860 0 0 {name=p4242 lab=_2228_/Y }
C {devices/lab_pin.sym} 5290 -19820 0 0 {name=p4243 lab=_2229_/Y }
C {devices/lab_pin.sym} 5290 -19780 0 0 {name=p4244 lab=_2230_/X }
C {devices/lab_pin.sym} 5450 -19820 0 1 {name=p4245 lab=_2231_/Y }
C {sky130_stdcells/a21oi_4.sym} 5370 -19820 0 0 {name=X_2231_ }
C {devices/lab_pin.sym} 5310 -19700 0 0 {name=p4246 lab=_2304_/A }
C {devices/lab_pin.sym} 5310 -19660 0 0 {name=p4247 lab=_2298_/B }
C {devices/lab_pin.sym} 5310 -19620 0 0 {name=p4248 lab=_2300_/C }
C {devices/lab_pin.sym} 5430 -19660 0 1 {name=p4249 lab=_2300_/Y }
C {sky130_stdcells/nand3_4.sym} 5370 -19660 0 0 {name=X_2300_ }
C {devices/lab_pin.sym} 5310 -19530 0 0 {name=p4250 lab=_1900_/A }
C {devices/lab_pin.sym} 5310 -19490 0 0 {name=p4251 lab=_2093_/B }
C {devices/lab_pin.sym} 5430 -19510 0 1 {name=p4252 lab=_2467_/D }
C {sky130_stdcells/and2_4.sym} 5370 -19510 0 0 {name=X_2093_ }
C {devices/lab_pin.sym} 5290 -19400 0 0 {name=p4253 lab=_2149_/Y }
C {devices/lab_pin.sym} 5290 -19360 0 0 {name=p4254 lab=_2160_/Y }
C {devices/lab_pin.sym} 5290 -19320 0 0 {name=p4255 lab=_2161_/Y }
C {devices/lab_pin.sym} 5450 -19360 0 1 {name=p4256 lab=_2162_/Y }
C {sky130_stdcells/o21ai_4.sym} 5370 -19360 0 0 {name=X_2162_ }
C {devices/lab_pin.sym} 5310 -19230 0 0 {name=p4257 lab=_1878_/A }
C {devices/lab_pin.sym} 5310 -19190 0 0 {name=p4258 lab=DATA_FROM_HASH[3] }
C {devices/lab_pin.sym} 5430 -19210 0 1 {name=p4259 lab=_2562_/D }
C {sky130_stdcells/and2_4.sym} 5370 -19210 0 0 {name=X_1877_ }
C {devices/lab_pin.sym} 5330 -19080 0 0 {name=p4260 lab=_2420_/Q }
C {devices/lab_pin.sym} 5410 -19080 0 1 {name=p4261 lab=_1947_/B }
C {sky130_stdcells/inv_2.sym} 5370 -19080 0 0 {name=X_1946_ }
C {devices/lab_pin.sym} 5280 -18960 0 0 {name=p4262 lab=_2428_/CLK }
C {devices/lab_pin.sym} 5280 -18940 0 0 {name=p4263 lab=_2429_/D }
C {devices/lab_pin.sym} 5460 -18960 0 1 {name=p4264 lab=_2177_/B }
C {sky130_stdcells/dfxtp_4.sym} 5370 -18950 0 0 {name=X_2429_ }
C {devices/lab_pin.sym} 5290 -18840 0 0 {name=p4265 lab=_1788_/X }
C {devices/lab_pin.sym} 5290 -18800 0 0 {name=p4266 lab=_2253_/C }
C {devices/lab_pin.sym} 5290 -18760 0 0 {name=p4267 lab=_1799_/X }
C {devices/lab_pin.sym} 5450 -18800 0 1 {name=p4268 lab=_1800_/X }
C {sky130_stdcells/o21a_4.sym} 5370 -18800 0 0 {name=X_1800_ }
C {devices/lab_pin.sym} 5330 -18660 0 0 {name=p4269 lab=_1662_/A }
C {devices/lab_pin.sym} 5410 -18660 0 1 {name=p4270 lab=_1662_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -18660 0 0 {name=X_1662_ }
C {devices/lab_pin.sym} 5310 -18560 0 0 {name=p4271 lab=_1697_/A }
C {devices/lab_pin.sym} 5310 -18520 0 0 {name=p4272 lab=_1731_/B }
C {devices/lab_pin.sym} 5310 -18480 0 0 {name=p4273 lab=_1689_/A }
C {devices/lab_pin.sym} 5430 -18520 0 1 {name=p4274 lab=_1731_/Y }
C {sky130_stdcells/nor3_4.sym} 5370 -18520 0 0 {name=X_1731_ }
C {devices/lab_pin.sym} 5310 -18390 0 0 {name=p4275 lab=_1762_/A }
C {devices/lab_pin.sym} 5310 -18350 0 0 {name=p4276 lab=_2436_/Q }
C {devices/lab_pin.sym} 5430 -18370 0 1 {name=p4277 lab=_2214_/Y }
C {sky130_stdcells/nand2_4.sym} 5370 -18370 0 0 {name=X_2214_ }
C {devices/lab_pin.sym} 5290 -18260 0 0 {name=p4278 lab=_1613_/A }
C {devices/lab_pin.sym} 5290 -18220 0 0 {name=p4279 lab=_1667_/B }
C {devices/lab_pin.sym} 5290 -18180 0 0 {name=p4280 lab=_1488_/X }
C {devices/lab_pin.sym} 5450 -18220 0 1 {name=p4281 lab=_1593_/Y }
C {sky130_stdcells/o21ai_4.sym} 5370 -18220 0 0 {name=X_1593_ }
C {devices/lab_pin.sym} 5290 -18100 0 0 {name=p4282 lab=_2071_/Y }
C {devices/lab_pin.sym} 5290 -18060 0 0 {name=p4283 lab=_2060_/B }
C {devices/lab_pin.sym} 5290 -18020 0 0 {name=p4284 lab=_1346_/X }
C {devices/lab_pin.sym} 5450 -18060 0 1 {name=p4285 lab=_2076_/Y }
C {sky130_stdcells/o21ai_4.sym} 5370 -18060 0 0 {name=X_2076_ }
C {devices/lab_pin.sym} 5290 -17960 0 0 {name=p4286 lab=_2144_/Y }
C {devices/lab_pin.sym} 5290 -17920 0 0 {name=p4287 lab=_2138_/Y }
C {devices/lab_pin.sym} 5290 -17880 0 0 {name=p4288 lab=_2125_/A }
C {devices/lab_pin.sym} 5290 -17840 0 0 {name=p4289 lab=_1966_/Y }
C {devices/lab_pin.sym} 5290 -17800 0 0 {name=p4290 lab=_2139_/X }
C {devices/lab_pin.sym} 5450 -17880 0 1 {name=p4291 lab=_2439_/D }
C {sky130_stdcells/o32ai_4.sym} 5370 -17880 0 0 {name=X_2145_ }
C {devices/lab_pin.sym} 5330 -17720 0 0 {name=p4292 lab=_2411_/Q }
C {devices/lab_pin.sym} 5410 -17720 0 1 {name=p4293 lab=_1929_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -17720 0 0 {name=X_1929_ }
C {devices/lab_pin.sym} 5330 -17600 0 0 {name=p4294 lab=_1645_/A }
C {devices/lab_pin.sym} 5410 -17600 0 1 {name=p4295 lab=_1646_/A }
C {sky130_stdcells/inv_2.sym} 5370 -17600 0 0 {name=X_1645_ }
C {devices/lab_pin.sym} 5290 -17520 0 0 {name=p4296 lab=_2337_/A }
C {devices/lab_pin.sym} 5290 -17480 0 0 {name=p4297 lab=_1575_/Y }
C {devices/lab_pin.sym} 5290 -17440 0 0 {name=p4298 lab=_1445_/A }
C {devices/lab_pin.sym} 5290 -17400 0 0 {name=p4299 lab=_1445_/D }
C {devices/lab_pin.sym} 5290 -17370 0 0 {name=p4300 lab=_1185_/A }
C {devices/lab_pin.sym} 5450 -17440 0 1 {name=p4301 lab=_1576_/X }
C {sky130_stdcells/a41o_4.sym} 5370 -17440 0 0 {name=X_1576_ }
C {devices/lab_pin.sym} 5310 -17290 0 0 {name=p4302 lab=_1630_/X }
C {devices/lab_pin.sym} 5310 -17250 0 0 {name=p4303 lab=_1713_/Y }
C {devices/lab_pin.sym} 5430 -17270 0 1 {name=p4304 lab=_1714_/Y }
C {sky130_stdcells/nor2_4.sym} 5370 -17270 0 0 {name=X_1714_ }
C {devices/lab_pin.sym} 5330 -17140 0 0 {name=p4305 lab=_1992_/D }
C {devices/lab_pin.sym} 5410 -17140 0 1 {name=p4306 lab=_2060_/B }
C {sky130_stdcells/buf_2.sym} 5370 -17140 0 0 {name=X_2059_ }
C {sky130_stdcells/decap_3.sym} 5370 -16990 0 0 {name=XPHY_59 }
C {sky130_stdcells/decap_3.sym} 5370 -16810 0 0 {name=XPHY_48 }
C {sky130_stdcells/decap_3.sym} 5370 -16630 0 0 {name=XPHY_15 }
C {devices/lab_pin.sym} 5310 -16500 0 0 {name=p4307 lab=_2125_/A }
C {devices/lab_pin.sym} 5310 -16460 0 0 {name=p4308 lab=_2335_/A }
C {devices/lab_pin.sym} 5310 -16420 0 0 {name=p4309 lab=_2445_/Q }
C {devices/lab_pin.sym} 5430 -16460 0 1 {name=p4310 lab=_2128_/Y }
C {sky130_stdcells/nand3_4.sym} 5370 -16460 0 0 {name=X_2128_ }
C {sky130_stdcells/decap_3.sym} 5370 -16290 0 0 {name=XPHY_26 }
C {sky130_stdcells/decap_3.sym} 5370 -16110 0 0 {name=XPHY_37 }
C {devices/lab_pin.sym} 5330 -15960 0 0 {name=p4311 lab=_2604_/Q }
C {devices/lab_pin.sym} 5410 -15960 0 1 {name=p4312 lab=_1701_/A }
C {sky130_stdcells/buf_2.sym} 5370 -15960 0 0 {name=X_1430_ }
C {devices/lab_pin.sym} 5310 -15850 0 0 {name=p4313 lab=_1360_/Y }
C {devices/lab_pin.sym} 5310 -15810 0 0 {name=p4314 lab=_1350_/X }
C {devices/lab_pin.sym} 5430 -15830 0 1 {name=p4315 lab=_1361_/Y }
C {sky130_stdcells/nor2_4.sym} 5370 -15830 0 0 {name=X_1361_ }
C {devices/lab_pin.sym} 5310 -15720 0 0 {name=p4316 lab=_1308_/A }
C {devices/lab_pin.sym} 5310 -15680 0 0 {name=p4317 lab=_1299_/A }
C {devices/lab_pin.sym} 5310 -15640 0 0 {name=p4318 lab=_1292_/C }
C {devices/lab_pin.sym} 5430 -15680 0 1 {name=p4319 lab=_1301_/A }
C {sky130_stdcells/nand3_4.sym} 5370 -15680 0 0 {name=X_1292_ }
C {devices/lab_pin.sym} 5310 -15550 0 0 {name=p4320 lab=_1570_/A }
C {devices/lab_pin.sym} 5310 -15510 0 0 {name=p4321 lab=_1559_/B }
C {devices/lab_pin.sym} 5430 -15530 0 1 {name=p4322 lab=_1667_/A }
C {sky130_stdcells/nor2_4.sym} 5370 -15530 0 0 {name=X_1559_ }
C {devices/lab_pin.sym} 5330 -15400 0 0 {name=p4323 lab=_2449_/Q }
C {devices/lab_pin.sym} 5410 -15400 0 1 {name=p4324 lab=_1628_/X }
C {sky130_stdcells/buf_2.sym} 5370 -15400 0 0 {name=X_1628_ }
C {devices/lab_pin.sym} 5280 -15280 0 0 {name=p4325 lab=_2590_/CLK }
C {devices/lab_pin.sym} 5280 -15260 0 0 {name=p4326 lab=_2600_/D }
C {devices/lab_pin.sym} 5460 -15280 0 1 {name=p4327 lab=_2600_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -15270 0 0 {name=X_2600_ }
C {devices/lab_pin.sym} 5330 -15140 0 0 {name=p4328 lab=_1409_/B }
C {devices/lab_pin.sym} 5410 -15140 0 1 {name=p4329 lab=_1413_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -15140 0 0 {name=X_1413_ }
C {devices/lab_pin.sym} 5280 -15020 0 0 {name=p4330 lab=_2570_/CLK }
C {devices/lab_pin.sym} 5280 -15000 0 0 {name=p4331 lab=_2393_/D }
C {devices/lab_pin.sym} 5460 -15020 0 1 {name=p4332 lab=_1697_/A }
C {sky130_stdcells/dfxtp_4.sym} 5370 -15010 0 0 {name=X_2393_ }
C {devices/lab_pin.sym} 5280 -14880 0 0 {name=p4333 lab=_2390_/CLK }
C {devices/lab_pin.sym} 5280 -14860 0 0 {name=p4334 lab=_2462_/D }
C {devices/lab_pin.sym} 5460 -14880 0 1 {name=p4335 lab=_1680_/B }
C {sky130_stdcells/dfxtp_4.sym} 5370 -14870 0 0 {name=X_2462_ }
C {devices/lab_pin.sym} 5280 -14740 0 0 {name=p4336 lab=_2513_/CLK }
C {devices/lab_pin.sym} 5280 -14720 0 0 {name=p4337 lab=_2531_/D }
C {devices/lab_pin.sym} 5460 -14740 0 1 {name=p4338 lab=HASH_ADDR[0] }
C {sky130_stdcells/dfxtp_4.sym} 5370 -14730 0 0 {name=X_2531_ }
C {devices/lab_pin.sym} 5330 -14600 0 0 {name=p4339 lab=_1274_/X }
C {devices/lab_pin.sym} 5410 -14600 0 1 {name=p4340 lab=_1275_/X }
C {sky130_stdcells/buf_2.sym} 5370 -14600 0 0 {name=X_1275_ }
C {devices/lab_pin.sym} 5290 -14500 0 0 {name=p4341 lab=_1324_/X }
C {devices/lab_pin.sym} 5290 -14460 0 0 {name=p4342 lab=_1321_/X }
C {devices/lab_pin.sym} 5290 -14420 0 0 {name=p4343 lab=_1329_/X }
C {devices/lab_pin.sym} 5450 -14460 0 1 {name=p4344 lab=_1344_/X }
C {sky130_stdcells/a21o_4.sym} 5370 -14460 0 0 {name=X_1344_ }
C {devices/lab_pin.sym} 5330 -14320 0 0 {name=p4345 lab=_2441_/Q }
C {devices/lab_pin.sym} 5410 -14320 0 1 {name=p4346 lab=_1963_/B }
C {sky130_stdcells/inv_2.sym} 5370 -14320 0 0 {name=X_1962_ }
C {devices/lab_pin.sym} 5310 -14210 0 0 {name=p4347 lab=_1896_/A }
C {devices/lab_pin.sym} 5310 -14170 0 0 {name=p4348 lab=DATA_AVAILABLE[2] }
C {devices/lab_pin.sym} 5430 -14190 0 1 {name=p4349 lab=_2549_/D }
C {sky130_stdcells/and2_4.sym} 5370 -14190 0 0 {name=X_1893_ }
C {devices/lab_pin.sym} 5280 -14060 0 0 {name=p4350 lab=_2498_/CLK }
C {devices/lab_pin.sym} 5280 -14040 0 0 {name=p4351 lab=_2376_/D }
C {devices/lab_pin.sym} 5460 -14060 0 1 {name=p4352 lab=_2377_/D }
C {sky130_stdcells/dfxtp_4.sym} 5370 -14050 0 0 {name=X_2376_ }
C {devices/lab_pin.sym} 5280 -13920 0 0 {name=p4353 lab=_2513_/CLK }
C {devices/lab_pin.sym} 5280 -13900 0 0 {name=p4354 lab=_1951_/X }
C {devices/lab_pin.sym} 5460 -13920 0 1 {name=p4355 lab=DATA_TO_HASH[7] }
C {sky130_stdcells/dfxtp_4.sym} 5370 -13910 0 0 {name=X_2514_ }
C {devices/lab_pin.sym} 5280 -13780 0 0 {name=p4356 lab=_2445_/CLK }
C {devices/lab_pin.sym} 5280 -13760 0 0 {name=p4357 lab=_2445_/D }
C {devices/lab_pin.sym} 5460 -13780 0 1 {name=p4358 lab=_2445_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -13770 0 0 {name=X_2445_ }
C {devices/lab_pin.sym} 5310 -13660 0 0 {name=p4359 lab=_1228_/Y }
C {devices/lab_pin.sym} 5310 -13620 0 0 {name=p4360 lab=_1240_/Y }
C {devices/lab_pin.sym} 5310 -13580 0 0 {name=p4361 lab=_1238_/Y }
C {devices/lab_pin.sym} 5430 -13620 0 1 {name=p4362 lab=_1258_/Y }
C {sky130_stdcells/nor3_4.sym} 5370 -13620 0 0 {name=X_1258_ }
C {devices/lab_pin.sym} 5330 -13480 0 0 {name=p4363 lab=_2384_/Q }
C {devices/lab_pin.sym} 5410 -13480 0 1 {name=p4364 lab=_1189_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -13480 0 0 {name=X_1189_ }
C {devices/lab_pin.sym} 5330 -13360 0 0 {name=p4365 lab=_1326_/Y }
C {devices/lab_pin.sym} 5410 -13360 0 1 {name=p4366 lab=_2633_/D }
C {sky130_stdcells/inv_2.sym} 5370 -13360 0 0 {name=X_1327_ }
C {devices/lab_pin.sym} 5290 -13260 0 0 {name=p4367 lab=_1612_/A }
C {devices/lab_pin.sym} 5290 -13220 0 0 {name=p4368 lab=_2621_/Q }
C {devices/lab_pin.sym} 5290 -13180 0 0 {name=p4369 lab=_1656_/A }
C {devices/lab_pin.sym} 5450 -13220 0 1 {name=p4370 lab=_2230_/X }
C {sky130_stdcells/a21o_4.sym} 5370 -13220 0 0 {name=X_2230_ }
C {devices/lab_pin.sym} 5310 -13090 0 0 {name=p4371 lab=_1222_/X }
C {devices/lab_pin.sym} 5310 -13050 0 0 {name=p4372 lab=_2091_/Y }
C {devices/lab_pin.sym} 5430 -13070 0 1 {name=p4373 lab=_2092_/Y }
C {sky130_stdcells/nor2_4.sym} 5370 -13070 0 0 {name=X_2092_ }
C {devices/lab_pin.sym} 5290 -12970 0 0 {name=p4374 lab=_1256_/Y }
C {devices/lab_pin.sym} 5290 -12930 0 0 {name=p4375 lab=_2148_/X }
C {devices/lab_pin.sym} 5290 -12890 0 0 {name=p4376 lab=_1651_/X }
C {devices/lab_pin.sym} 5290 -12850 0 0 {name=p4377 lab=_1856_/A }
C {devices/lab_pin.sym} 5450 -12910 0 1 {name=p4378 lab=_2161_/Y }
C {sky130_stdcells/a2bb2oi_4.sym} 5370 -12910 0 0 {name=X_2161_ }
C {devices/lab_pin.sym} 5310 -12770 0 0 {name=p4379 lab=_1947_/A }
C {devices/lab_pin.sym} 5310 -12730 0 0 {name=p4380 lab=_1945_/B }
C {devices/lab_pin.sym} 5430 -12750 0 1 {name=p4381 lab=_1945_/Y }
C {sky130_stdcells/nor2_4.sym} 5370 -12750 0 0 {name=X_1945_ }
C {devices/lab_pin.sym} 5310 -12630 0 0 {name=p4382 lab=_1878_/A }
C {devices/lab_pin.sym} 5310 -12590 0 0 {name=p4383 lab=DATA_FROM_HASH[4] }
C {devices/lab_pin.sym} 5430 -12610 0 1 {name=p4384 lab=_1876_/X }
C {sky130_stdcells/and2_4.sym} 5370 -12610 0 0 {name=X_1876_ }
C {devices/lab_pin.sym} 5330 -12480 0 0 {name=p4385 lab=EXT_RESET_N_fromHost }
C {devices/lab_pin.sym} 5410 -12480 0 1 {name=p4386 lab=EXT_RESET_N_toClient }
C {sky130_stdcells/buf_2.sym} 5370 -12480 0 0 {name=X_2359_ }
C {devices/lab_pin.sym} 5280 -12360 0 0 {name=p4387 lab=_2428_/CLK }
C {devices/lab_pin.sym} 5280 -12340 0 0 {name=p4388 lab=_2428_/D }
C {devices/lab_pin.sym} 5460 -12360 0 1 {name=p4389 lab=_2428_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -12350 0 0 {name=X_2428_ }
C {devices/lab_pin.sym} 5330 -12220 0 0 {name=p4390 lab=clkbuf_4_3_0_addressalyzerBlock.SPI_CLK/A }
C {devices/lab_pin.sym} 5410 -12220 0 1 {name=p4391 lab=_2410_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 5370 -12220 0 0 {name=Xclkbuf_4_3_0_addressalyzerBlock.SPI_CLK }
C {devices/lab_pin.sym} 5310 -12130 0 0 {name=p4392 lab=_1383_/C }
C {devices/lab_pin.sym} 5310 -12090 0 0 {name=p4393 lab=_1860_/B }
C {devices/lab_pin.sym} 5310 -12050 0 0 {name=p4394 lab=_1661_/C }
C {devices/lab_pin.sym} 5310 -12010 0 0 {name=p4395 lab=_1661_/D }
C {devices/lab_pin.sym} 5430 -12070 0 1 {name=p4396 lab=_1661_/X }
C {sky130_stdcells/or4_4.sym} 5370 -12070 0 0 {name=X_1661_ }
C {devices/lab_pin.sym} 5290 -11950 0 0 {name=p4397 lab=_1728_/C }
C {devices/lab_pin.sym} 5290 -11910 0 0 {name=p4398 lab=_1434_/Y }
C {devices/lab_pin.sym} 5290 -11870 0 0 {name=p4399 lab=_1728_/Y }
C {devices/lab_pin.sym} 5290 -11830 0 0 {name=p4400 lab=_1729_/Y }
C {devices/lab_pin.sym} 5450 -11890 0 1 {name=p4401 lab=_1730_/X }
C {sky130_stdcells/a211o_4.sym} 5370 -11890 0 0 {name=X_1730_ }
C {devices/lab_pin.sym} 5310 -11750 0 0 {name=p4402 lab=_1426_/A }
C {devices/lab_pin.sym} 5310 -11710 0 0 {name=p4403 lab=_1664_/A }
C {devices/lab_pin.sym} 5430 -11730 0 1 {name=p4404 lab=_1667_/B }
C {sky130_stdcells/nor2_4.sym} 5370 -11730 0 0 {name=X_1592_ }
C {devices/lab_pin.sym} 5290 -11630 0 0 {name=p4405 lab=_2544_/Q }
C {devices/lab_pin.sym} 5290 -11590 0 0 {name=p4406 lab=_1739_/B }
C {devices/lab_pin.sym} 5290 -11550 0 0 {name=p4407 lab=_2212_/Y }
C {devices/lab_pin.sym} 5290 -11510 0 0 {name=p4408 lab=_2168_/Y }
C {devices/lab_pin.sym} 5450 -11570 0 1 {name=p4409 lab=_2213_/Y }
C {sky130_stdcells/a22oi_4.sym} 5370 -11570 0 0 {name=X_2213_ }
C {devices/lab_pin.sym} 5330 -11420 0 0 {name=p4410 lab=_1520_/X }
C {devices/lab_pin.sym} 5410 -11420 0 1 {name=p4411 lab=_2144_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -11420 0 0 {name=X_2144_ }
C {devices/lab_pin.sym} 5330 -11300 0 0 {name=p4412 lab=_2075_/A }
C {devices/lab_pin.sym} 5410 -11300 0 1 {name=p4413 lab=_2075_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -11300 0 0 {name=X_2075_ }
C {devices/lab_pin.sym} 5290 -11200 0 0 {name=p4414 lab=_1612_/X }
C {devices/lab_pin.sym} 5290 -11160 0 0 {name=p4415 lab=_1857_/Y }
C {devices/lab_pin.sym} 5290 -11120 0 0 {name=p4416 lab=_1858_/Y }
C {devices/lab_pin.sym} 5450 -11160 0 1 {name=p4417 lab=_1859_/Y }
C {sky130_stdcells/o21ai_4.sym} 5370 -11160 0 0 {name=X_1859_ }
C {devices/lab_pin.sym} 5310 -11030 0 0 {name=p4418 lab=_1930_/A }
C {devices/lab_pin.sym} 5310 -10990 0 0 {name=p4419 lab=_1927_/Y }
C {devices/lab_pin.sym} 5430 -11010 0 1 {name=p4420 lab=_2528_/D }
C {sky130_stdcells/nor2_4.sym} 5370 -11010 0 0 {name=X_1928_ }
C {devices/lab_pin.sym} 5330 -10880 0 0 {name=p4421 lab=clkbuf_2_3_0_m1_clk_local/A }
C {devices/lab_pin.sym} 5410 -10880 0 1 {name=p4422 lab=clkbuf_3_4_0_m1_clk_local/A }
C {sky130_stdcells/clkbuf_1.sym} 5370 -10880 0 0 {name=Xclkbuf_2_2_0_m1_clk_local }
C {devices/lab_pin.sym} 5330 -10760 0 0 {name=p4423 lab=_1768_/B }
C {devices/lab_pin.sym} 5410 -10760 0 1 {name=p4424 lab=_1713_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -10760 0 0 {name=X_1713_ }
C {devices/lab_pin.sym} 5330 -10640 0 0 {name=p4425 lab=_1643_/X }
C {devices/lab_pin.sym} 5410 -10640 0 1 {name=p4426 lab=_1645_/A }
C {sky130_stdcells/buf_2.sym} 5370 -10640 0 0 {name=X_1644_ }
C {devices/lab_pin.sym} 5330 -10520 0 0 {name=p4427 lab=_1566_/A }
C {devices/lab_pin.sym} 5410 -10520 0 1 {name=p4428 lab=_1575_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -10520 0 0 {name=X_1575_ }
C {devices/lab_pin.sym} 5310 -10420 0 0 {name=p4429 lab=_1840_/B }
C {devices/lab_pin.sym} 5310 -10380 0 0 {name=p4430 lab=_2121_/X }
C {devices/lab_pin.sym} 5310 -10340 0 0 {name=p4431 lab=_1459_/A }
C {devices/lab_pin.sym} 5430 -10380 0 1 {name=p4432 lab=_2127_/Y }
C {sky130_stdcells/nand3_4.sym} 5370 -10380 0 0 {name=X_2127_ }
C {devices/lab_pin.sym} 5330 -10240 0 0 {name=p4433 lab=_2477_/Q }
C {devices/lab_pin.sym} 5410 -10240 0 1 {name=p4434 lab=_2058_/X }
C {sky130_stdcells/buf_2.sym} 5370 -10240 0 0 {name=X_2058_ }
C {sky130_stdcells/decap_3.sym} 5370 -10090 0 0 {name=XPHY_49 }
C {sky130_stdcells/decap_3.sym} 5370 -9910 0 0 {name=XPHY_16 }
C {sky130_stdcells/decap_3.sym} 5370 -9730 0 0 {name=XPHY_27 }
C {sky130_stdcells/decap_3.sym} 5370 -9550 0 0 {name=XPHY_38 }
C {devices/lab_pin.sym} 5330 -9400 0 0 {name=p4435 lab=_1360_/A }
C {devices/lab_pin.sym} 5410 -9400 0 1 {name=p4436 lab=_1360_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -9400 0 0 {name=X_1360_ }
C {devices/lab_pin.sym} 5330 -9280 0 0 {name=p4437 lab=_1246_/Y }
C {devices/lab_pin.sym} 5410 -9280 0 1 {name=p4438 lab=_1308_/A }
C {sky130_stdcells/inv_2.sym} 5370 -9280 0 0 {name=X_1291_ }
C {devices/lab_pin.sym} 5330 -9160 0 0 {name=p4439 lab=_1428_/B }
C {devices/lab_pin.sym} 5410 -9160 0 1 {name=p4440 lab=_1559_/B }
C {sky130_stdcells/inv_2.sym} 5370 -9160 0 0 {name=X_1558_ }
C {devices/lab_pin.sym} 5290 -9060 0 0 {name=p4441 lab=_1622_/Y }
C {devices/lab_pin.sym} 5290 -9020 0 0 {name=p4442 lab=_1624_/X }
C {devices/lab_pin.sym} 5290 -8980 0 0 {name=p4443 lab=_1626_/Y }
C {devices/lab_pin.sym} 5450 -9020 0 1 {name=p4444 lab=_1627_/Y }
C {sky130_stdcells/o21ai_4.sym} 5370 -9020 0 0 {name=X_1627_ }
C {devices/lab_pin.sym} 5290 -8900 0 0 {name=p4445 lab=_1487_/Y }
C {devices/lab_pin.sym} 5290 -8860 0 0 {name=p4446 lab=_1488_/X }
C {devices/lab_pin.sym} 5290 -8820 0 0 {name=p4447 lab=_1450_/X }
C {devices/lab_pin.sym} 5450 -8860 0 1 {name=p4448 lab=_1489_/X }
C {sky130_stdcells/a21o_4.sym} 5370 -8860 0 0 {name=X_1489_ }
C {devices/lab_pin.sym} 5330 -8720 0 0 {name=p4449 lab=clkbuf_4_5_0_m1_clk_local/A }
C {devices/lab_pin.sym} 5410 -8720 0 1 {name=p4450 lab=_2483_/CLK }
C {sky130_stdcells/clkbuf_1.sym} 5370 -8720 0 0 {name=Xclkbuf_4_5_0_m1_clk_local }
C {devices/lab_pin.sym} 5280 -8600 0 0 {name=p4451 lab=_2528_/CLK }
C {devices/lab_pin.sym} 5280 -8580 0 0 {name=p4452 lab=_1924_/Y }
C {devices/lab_pin.sym} 5460 -8600 0 1 {name=p4453 lab=_1931_/B }
C {sky130_stdcells/dfxtp_4.sym} 5370 -8590 0 0 {name=X_2530_ }
C {devices/lab_pin.sym} 5310 -8480 0 0 {name=p4454 lab=_1411_/X }
C {devices/lab_pin.sym} 5310 -8440 0 0 {name=p4455 lab=_2010_/B }
C {devices/lab_pin.sym} 5310 -8400 0 0 {name=p4456 lab=_1397_/C }
C {devices/lab_pin.sym} 5430 -8440 0 1 {name=p4457 lab=_1412_/X }
C {sky130_stdcells/and3_4.sym} 5370 -8440 0 0 {name=X_1412_ }
C {devices/lab_pin.sym} 5290 -8320 0 0 {name=p4458 lab=_1335_/D }
C {devices/lab_pin.sym} 5290 -8280 0 0 {name=p4459 lab=_1333_/Y }
C {devices/lab_pin.sym} 5290 -8240 0 0 {name=p4460 lab=_1342_/Y }
C {devices/lab_pin.sym} 5450 -8280 0 1 {name=p4461 lab=_1343_/X }
C {sky130_stdcells/o21a_4.sym} 5370 -8280 0 0 {name=X_1343_ }
C {devices/lab_pin.sym} 5280 -8140 0 0 {name=p4462 lab=_2570_/CLK }
C {devices/lab_pin.sym} 5280 -8120 0 0 {name=p4463 lab=_2392_/D }
C {devices/lab_pin.sym} 5460 -8140 0 1 {name=p4464 lab=_2392_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -8130 0 0 {name=X_2392_ }
C {devices/lab_pin.sym} 5280 -8000 0 0 {name=p4465 lab=_2390_/CLK }
C {devices/lab_pin.sym} 5280 -7980 0 0 {name=p4466 lab=_2461_/D }
C {devices/lab_pin.sym} 5460 -8000 0 1 {name=p4467 lab=_2461_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -7990 0 0 {name=X_2461_ }
C {devices/lab_pin.sym} 5330 -7860 0 0 {name=p4468 lab=_2363_/Q }
C {devices/lab_pin.sym} 5410 -7860 0 1 {name=p4469 lab=_1274_/X }
C {sky130_stdcells/buf_2.sym} 5370 -7860 0 0 {name=X_1274_ }
C {devices/lab_pin.sym} 5330 -7740 0 0 {name=p4470 lab=_2096_/A }
C {devices/lab_pin.sym} 5410 -7740 0 1 {name=p4471 lab=_1896_/A }
C {sky130_stdcells/buf_2.sym} 5370 -7740 0 0 {name=X_1892_ }
C {devices/lab_pin.sym} 5310 -7630 0 0 {name=p4472 lab=_1947_/A }
C {devices/lab_pin.sym} 5310 -7590 0 0 {name=p4473 lab=_1960_/Y }
C {devices/lab_pin.sym} 5430 -7610 0 1 {name=p4474 lab=_2506_/D }
C {sky130_stdcells/nor2_4.sym} 5370 -7610 0 0 {name=X_1961_ }
C {devices/lab_pin.sym} 5280 -7480 0 0 {name=p4475 lab=_2513_/CLK }
C {devices/lab_pin.sym} 5280 -7460 0 0 {name=p4476 lab=_1952_/X }
C {devices/lab_pin.sym} 5460 -7480 0 1 {name=p4477 lab=DATA_TO_HASH[6] }
C {sky130_stdcells/dfxtp_4.sym} 5370 -7470 0 0 {name=X_2513_ }
C {devices/lab_pin.sym} 5280 -7340 0 0 {name=p4478 lab=_2496_/CLK }
C {devices/lab_pin.sym} 5280 -7320 0 0 {name=p4479 lab=_2375_/D }
C {devices/lab_pin.sym} 5460 -7340 0 1 {name=p4480 lab=_2376_/D }
C {sky130_stdcells/dfxtp_4.sym} 5370 -7330 0 0 {name=X_2375_ }
C {devices/lab_pin.sym} 5290 -7220 0 0 {name=p4481 lab=_1316_/B }
C {devices/lab_pin.sym} 5290 -7180 0 0 {name=p4482 lab=_1323_/Y }
C {devices/lab_pin.sym} 5290 -7140 0 0 {name=p4483 lab=_1325_/Y }
C {devices/lab_pin.sym} 5450 -7180 0 1 {name=p4484 lab=_1326_/Y }
C {sky130_stdcells/o21ai_4.sym} 5370 -7180 0 0 {name=X_1326_ }
C {devices/lab_pin.sym} 5280 -7040 0 0 {name=p4485 lab=_2445_/CLK }
C {devices/lab_pin.sym} 5280 -7020 0 0 {name=p4486 lab=_2444_/D }
C {devices/lab_pin.sym} 5460 -7040 0 1 {name=p4487 lab=_2444_/Q }
C {sky130_stdcells/dfxtp_4.sym} 5370 -7030 0 0 {name=X_2444_ }
C {devices/lab_pin.sym} 5330 -6900 0 0 {name=p4488 lab=_1188_/A }
C {devices/lab_pin.sym} 5410 -6900 0 1 {name=p4489 lab=_1216_/B }
C {sky130_stdcells/buf_2.sym} 5370 -6900 0 0 {name=X_1188_ }
C {devices/lab_pin.sym} 5330 -6780 0 0 {name=p4490 lab=_1257_/A }
C {devices/lab_pin.sym} 5410 -6780 0 1 {name=p4491 lab=_1257_/X }
C {sky130_stdcells/buf_2.sym} 5370 -6780 0 0 {name=X_1257_ }
C {devices/lab_pin.sym} 5280 -6660 0 0 {name=p4492 lab=DATA_AVAILABLE[2] }
C {sky130_stdcells/diode_2.sym} 5370 -6660 0 0 {name=XINSDIODE2_0 }
C {devices/lab_pin.sym} 5290 -6560 0 0 {name=p4493 lab=_2157_/X }
C {devices/lab_pin.sym} 5290 -6520 0 0 {name=p4494 lab=_2159_/X }
C {devices/lab_pin.sym} 5290 -6480 0 0 {name=p4495 lab=_1701_/A }
C {devices/lab_pin.sym} 5450 -6520 0 1 {name=p4496 lab=_2160_/Y }
C {sky130_stdcells/a21oi_4.sym} 5370 -6520 0 0 {name=X_2160_ }
C {devices/lab_pin.sym} 5330 -6380 0 0 {name=p4497 lab=_2467_/Q }
C {devices/lab_pin.sym} 5410 -6380 0 1 {name=p4498 lab=_2091_/Y }
C {sky130_stdcells/inv_2.sym} 5370 -6380 0 0 {name=X_2091_ }
C {devices/lab_pin.sym} 5310 -6270 0 0 {name=p4499 lab=_1878_/A }
C {devices/lab_pin.sym} 5310 -6230 0 0 {name=p4500 lab=DATA_FROM_HASH[5] }
C {devices/lab_pin.sym} 5430 -6250 0 1 {name=p4501 lab=_2564_/D }
C {sky130_stdcells/and2_4.sym} 5370 -6250 0 0 {name=X_1875_ }
C {devices/lab_pin.sym} 5330 -6120 0 0 {name=p4502 lab=_1944_/A }
C {devices/lab_pin.sym} 5410 -6120 0 1 {name=p4503 lab=_1945_/B }
C {sky130_stdcells/inv_2.sym} 5370 -6120 0 0 {name=X_1944_ }
C {devices/lab_pin.sym} 5280 -6000 0 0 {name=p4504 lab=_2445_/CLK }
C {devices/lab_pin.sym} 5280 -5980 0 0 {name=p4505 lab=_2427_/D }
C {devices/lab_pin.sym} 5460 -6000 0 1 {name=p4506 lab=_1913_/A }
C {sky130_stdcells/dfxtp_4.sym} 5370 -5990 0 0 {name=X_2427_ }
C {devices/lab_pin.sym} 5310 -5870 0 0 {name=p4507 lab=_1307_/X }
C {devices/lab_pin.sym} 5310 -5830 0 0 {name=p4508 lab=_1308_/Y }
C {devices/lab_pin.sym} 5430 -5850 0 1 {name=p4509 lab=_1309_/Y }
C {sky130_stdcells/nand2_4.sym} 5370 -5850 0 0 {name=X_1309_ }
C {devices/lab_pin.sym} 5310 -5750 0 0 {name=p4510 lab=_1219_/X }
C {devices/lab_pin.sym} 5310 -5710 0 0 {name=p4511 lab=_1579_/X }
C {devices/lab_pin.sym} 5310 -5670 0 0 {name=p4512 lab=_1691_/Y }
C {devices/lab_pin.sym} 5310 -5630 0 0 {name=p4513 lab=_1562_/A }
C {devices/lab_pin.sym} 5430 -5690 0 1 {name=p4514 lab=_2290_/A }
C {sky130_stdcells/nor4_4.sym} 5370 -5690 0 0 {name=X_2289_ }
C {devices/lab_pin.sym} 5430 -5550 0 1 {name=p4515 lab=_2358_/HI }
C {devices/lab_pin.sym} 5430 -5510 0 1 {name=p4516 lab=zero }
C {sky130_stdcells/conb_1.sym} 5370 -5530 0 0 {name=X_2358_ }
C {devices/lab_pin.sym} 5330 -5400 0 0 {name=p4517 lab=_1660_/A }
C {devices/lab_pin.sym} 5410 -5400 0 1 {name=p4518 lab=_1661_/D }
C {sky130_stdcells/buf_2.sym} 5370 -5400 0 0 {name=X_1660_ }
C {devices/lab_pin.sym} 5330 -5280 0 0 {name=p4519 lab=_1427_/A }
