$ Spice netlist generated by v2lvs
$ v2018.4_34.26    Mon Dec 3 14:40:42 PST 2018
.INCLUDE "/usr/local/google/home/tansell/work/openflow-drc-tests/torture_tests/sky130_ef_io__vssd_lvc_clamped2_pad//libraries.cdl"
*.BUSDELIMITER [

.SUBCKT sky130_ef_io__vssd_lvc_clamped2_pad AMUXBUS_A AMUXBUS_B VSSA VDDA
+ VSWITCH VDDIO_Q VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
Xsky130_fd_io__top_ground_lvc_base sky130_fd_io__top_ground_lvc_wpad $PINS
+ VSSA=VSSA VDDA=VDDA VSWITCH=VSWITCH VDDIO_Q=VDDIO_Q VCCHIB=VCCHIB VDDIO=VDDIO
+ VCCD=VCCD VSSIO=VSSIO VSSD=VSSD VSSIO_Q=VSSIO_Q G_PAD=VSSD BDY2_B2B=VSSIO
+ AMUXBUS_A=AMUXBUS_A AMUXBUS_B=AMUXBUS_B DRN_LVC1=VCCD DRN_LVC2=VCCD
+ SRC_BDY_LVC1=VSSD SRC_BDY_LVC2=VSSD
.ENDS
