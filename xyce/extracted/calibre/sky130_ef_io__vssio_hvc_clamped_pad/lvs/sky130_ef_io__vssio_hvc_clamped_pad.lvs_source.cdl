$ Spice netlist generated by v2lvs
$ v2018.4_34.26    Mon Dec 3 14:40:42 PST 2018
.INCLUDE "/usr/local/google/home/tansell/work/openflow-drc-tests/torture_tests/sky130_ef_io__vssio_hvc_clamped_pad//libraries.cdl"
*.BUSDELIMITER [

.SUBCKT sky130_ef_io__vssio_hvc_clamped_pad AMUXBUS_A AMUXBUS_B VSSA VDDA
+ VSWITCH VDDIO_Q VCCHIB VDDIO VCCD VSSIO VSSD VSSIO_Q
*.CONNECT VSSIO_Q VSSIO
Xsky130_fd_io__top_ground_hvc_base sky130_fd_io__top_ground_hvc_wpad $PINS
+ VSSA=VSSA VDDA=VDDA VSWITCH=VSWITCH VDDIO_Q=VDDIO_Q VCCHIB=VCCHIB VDDIO=VDDIO
+ VCCD=VCCD VSSIO=VSSIO VSSD=VSSD VSSIO_Q=VSSIO_Q G_PAD=VSSIO AMUXBUS_A=AMUXBUS_A
+ AMUXBUS_B=AMUXBUS_B DRN_HVC=VDDIO SRC_BDY_HVC=VSSIO
.ENDS
