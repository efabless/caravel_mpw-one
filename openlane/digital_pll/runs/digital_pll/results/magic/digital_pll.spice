* NGSPICE file created from digital_pll.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_1 abstract view
.subckt sky130_fd_sc_hd__clkinv_1 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_4 abstract view
.subckt sky130_fd_sc_hd__a32o_4 A1 A2 A3 B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_4 abstract view
.subckt sky130_fd_sc_hd__and4_4 A B C D X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__einvp_2 abstract view
.subckt sky130_fd_sc_hd__einvp_2 A TE Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_8 abstract view
.subckt sky130_fd_sc_hd__inv_8 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__einvn_8 abstract view
.subckt sky130_fd_sc_hd__einvn_8 A TE_B Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_4 abstract view
.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__einvn_4 abstract view
.subckt sky130_fd_sc_hd__einvn_4 A TE_B Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_4 abstract view
.subckt sky130_fd_sc_hd__xnor2_4 A B Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_4 abstract view
.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor4_4 abstract view
.subckt sky130_fd_sc_hd__nor4_4 A B C D Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfrtp_4 abstract view
.subckt sky130_fd_sc_hd__dfrtp_4 D Q RESET_B CLK VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__einvp_1 abstract view
.subckt sky130_fd_sc_hd__einvp_1 A TE Z VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_4 abstract view
.subckt sky130_fd_sc_hd__nor3_4 A B C Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_4 abstract view
.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_4 abstract view
.subckt sky130_fd_sc_hd__xor2_4 A B X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_2 abstract view
.subckt sky130_fd_sc_hd__clkinv_2 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand4_4 abstract view
.subckt sky130_fd_sc_hd__nand4_4 A B C D Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkinv_8 abstract view
.subckt sky130_fd_sc_hd__clkinv_8 A Y VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o32a_4 abstract view
.subckt sky130_fd_sc_hd__o32a_4 A1 A2 A3 B1 B2 X VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_2 abstract view
.subckt sky130_fd_sc_hd__or2_2 A B X VGND VPWR
.ends

.subckt digital_pll clockp[0] clockp[1] dco div[0] div[1] div[2] div[3] div[4] enable
+ ext_trim[0] ext_trim[10] ext_trim[11] ext_trim[12] ext_trim[13] ext_trim[14] ext_trim[15]
+ ext_trim[16] ext_trim[17] ext_trim[18] ext_trim[19] ext_trim[1] ext_trim[20] ext_trim[21]
+ ext_trim[22] ext_trim[23] ext_trim[24] ext_trim[25] ext_trim[2] ext_trim[3] ext_trim[4]
+ ext_trim[5] ext_trim[6] ext_trim[7] ext_trim[8] ext_trim[9] osc resetb VPWR VGND
XFILLER_13_111 VGND VPWR sky130_fd_sc_hd__decap_4
X_501_ _499_/A _501_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_26_63 VGND VPWR sky130_fd_sc_hd__decap_3
X_432_ _432_/A _432_/B _465_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_294_ _291_/A _290_/Y _293_/Y _292_/X _294_/X VGND VPWR sky130_fd_sc_hd__a211o_4
X_363_ _365_/A _367_/B _264_/Y _363_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_13_166 VGND VPWR sky130_fd_sc_hd__fill_2
Xringosc.dstage\[1\].id.delayint0 ringosc.dstage\[1\].id.delayen1/Z ringosc.dstage\[1\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_27_214 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_147 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_136 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_62 VGND VPWR sky130_fd_sc_hd__decap_12
X_346_ _320_/Y _340_/Y _345_/X _415_/B _320_/A _346_/X VGND VPWR sky130_fd_sc_hd__a32o_4
X_415_ _395_/A _415_/B _415_/C _396_/C _415_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_277_ _275_/X _276_/Y _275_/X _276_/Y _277_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_5_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_250 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[11\].id.delayen1 ringosc.dstage\[11\].id.delayen1/A _487_/X ringosc.dstage\[11\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_9_66 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_33 VGND VPWR sky130_fd_sc_hd__decap_8
X_329_ _329_/A _395_/D VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_11_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_139 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_172 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_227 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[10\].id.delayenb0 ringosc.dstage\[10\].id.delaybuf0/X _422_/X ringosc.dstage\[10\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_6_23 VGND VPWR sky130_fd_sc_hd__decap_8
Xringosc.dstage\[9\].id.delayenb0 ringosc.dstage\[9\].id.delaybuf0/X _421_/X ringosc.dstage\[9\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_6_45 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_194 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_120 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_142 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_54 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_230 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_245 VGND VPWR sky130_fd_sc_hd__decap_6
X_500_ _499_/A _500_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_362_ _365_/C _361_/X _264_/Y _521_/D VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_13_123 VGND VPWR sky130_fd_sc_hd__decap_8
X_431_ _396_/C _403_/D _431_/C _415_/B _432_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_42_63 VGND VPWR sky130_fd_sc_hd__decap_12
X_293_ div[3] _293_/B _293_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_42_218 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_55 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_74 VGND VPWR sky130_fd_sc_hd__decap_12
X_276_ _369_/B _276_/B _276_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_345_ _340_/A _340_/B _345_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_414_ _456_/A _413_/X _417_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_5_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_259_ _522_/Q _311_/B VGND VPWR sky130_fd_sc_hd__inv_8
X_328_ _474_/D _308_/B _329_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_20_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_86 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_107 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_184 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_4_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_75 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.dstage\[10\].id.delayenb1 ringosc.dstage\[10\].id.delaybuf0/X _484_/X ringosc.dstage\[10\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
Xringosc.dstage\[9\].id.delayenb1 ringosc.dstage\[9\].id.delaybuf0/X _483_/X ringosc.dstage\[9\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_28_162 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_173 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_110 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_113 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_135 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_146 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_99 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_242 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_154 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_102 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_113 VGND VPWR sky130_fd_sc_hd__decap_4
X_292_ div[3] _293_/B _291_/X _292_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_361_ _365_/A _367_/B _361_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_13_179 VGND VPWR sky130_fd_sc_hd__decap_4
X_430_ _395_/A _396_/B _415_/C _253_/A _432_/A VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_42_75 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_58 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_205 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_150 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_116 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_413_ _413_/A _403_/D _413_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_37_86 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_241 VGND VPWR sky130_fd_sc_hd__decap_3
X_275_ _249_/Y _250_/Y _249_/Y _250_/Y _275_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_344_ _320_/Y _343_/X _342_/Y _431_/C _320_/A _344_/X VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_5_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_219 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_112 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_167 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[4\].id.delayen0 ringosc.dstage\[4\].id.delayen0/A _407_/X ringosc.dstage\[4\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
X_258_ _258_/A _316_/C VGND VPWR sky130_fd_sc_hd__inv_8
X_327_ _330_/A _396_/D VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_36_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_222 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_44 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_133 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_199 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_122 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_199 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_147 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[10\].id.delaybuf0 ringosc.dstage\[9\].id.delayen0/Z ringosc.dstage\[10\].id.delaybuf0/X
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
Xringosc.dstage\[9\].id.delaybuf0 ringosc.dstage\[8\].id.delayen0/Z ringosc.dstage\[9\].id.delaybuf0/X
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
Xringosc.dstage\[5\].id.delayenb0 ringosc.dstage\[5\].id.delaybuf1/A _408_/X ringosc.ibufp10/A
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_26_55 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_87 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_118 VGND VPWR sky130_fd_sc_hd__decap_4
X_360_ _518_/Q _369_/B _519_/Q _367_/B VGND VPWR sky130_fd_sc_hd__and3_4
X_291_ _291_/A _290_/Y _291_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_3_15 VGND VPWR sky130_fd_sc_hd__fill_2
X_489_ _454_/A _485_/X _488_/X _398_/X _489_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_18_239 VGND VPWR sky130_fd_sc_hd__decap_12
X_412_ _431_/C _415_/B _396_/C _415_/C _456_/A VGND VPWR sky130_fd_sc_hd__and4_4
X_274_ _314_/D _314_/B _274_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_343_ _342_/A _342_/B _343_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_2_179 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.dstage\[4\].id.delayen1 ringosc.dstage\[4\].id.delayen1/A _463_/X ringosc.dstage\[4\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
X_326_ _525_/Q _377_/B _330_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_257_ _308_/B _377_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_29_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_234 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_99 VGND VPWR sky130_fd_sc_hd__fill_1
X_309_ _309_/A _415_/C VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_29_44 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_186 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_197 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_88 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_35 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_134 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_211 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_145 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xringosc.dstage\[10\].id.delaybuf1 ringosc.dstage\[10\].id.delaybuf0/X ringosc.dstage\[10\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xringosc.dstage\[9\].id.delaybuf1 ringosc.dstage\[9\].id.delaybuf0/X ringosc.dstage\[9\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xringosc.dstage\[5\].id.delayenb1 ringosc.dstage\[5\].id.delaybuf1/A _467_/X ringosc.dstage\[5\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_11_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_44 VGND VPWR sky130_fd_sc_hd__decap_12
X_290_ _286_/X _289_/Y _290_/Y VGND VPWR sky130_fd_sc_hd__xnor2_4
XFILLER_21_192 VGND VPWR sky130_fd_sc_hd__fill_2
X_488_ _488_/A _460_/A _394_/B _417_/A _488_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_27_229 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_221 VGND VPWR sky130_fd_sc_hd__decap_12
X_342_ _342_/A _342_/B _342_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_411_ _389_/A _411_/B _479_/C VGND VPWR sky130_fd_sc_hd__or2_4
X_273_ _252_/Y _314_/B _314_/D _314_/B _530_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_32_221 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_23_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_136 VGND VPWR sky130_fd_sc_hd__decap_12
X_325_ _325_/A _325_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_256_ _525_/Q _474_/D VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_20_246 VGND VPWR sky130_fd_sc_hd__decap_4
X_308_ _525_/Q _308_/B _309_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_41_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_198 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_110 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_132 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_154 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_187 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_79 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_22_127 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_92 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_56 VGND VPWR sky130_fd_sc_hd__decap_6
X_487_ _388_/Y _486_/Y _473_/Y dco ext_trim[24] _487_/X VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_8_142 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_182 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_230 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.dstage\[5\].id.delaybuf0 ringosc.dstage\[4\].id.delayen0/Z ringosc.dstage\[5\].id.delaybuf1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_10_108 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[1\].id.delayenb0 ringosc.dstage\[1\].id.delayenb0/A _392_/X ringosc.dstage\[1\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_41_233 VGND VPWR sky130_fd_sc_hd__decap_8
X_272_ _252_/Y _264_/Y _314_/C _264_/Y _272_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_410_ _413_/A _378_/A _411_/B VGND VPWR sky130_fd_sc_hd__and2_4
X_341_ _396_/B _306_/A _340_/Y _342_/B VGND VPWR sky130_fd_sc_hd__o21a_4
Xringosc.dstage\[8\].id.delayint0 ringosc.dstage\[8\].id.delayen1/Z ringosc.dstage\[8\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_5_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_112 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_230 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_200 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_60 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_93 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_211 VGND VPWR sky130_fd_sc_hd__decap_3
X_324_ _474_/D _318_/B _525_/Q _306_/A _325_/A VGND VPWR sky130_fd_sc_hd__o22a_4
X_255_ _415_/B _396_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_1_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_3 VGND VPWR sky130_fd_sc_hd__decap_12
X_307_ _431_/C _415_/B _446_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_34_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_59 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_122 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_155 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_106 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_58 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_191 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_106 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_0 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_117 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_194 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_71 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_150 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_91 VGND VPWR sky130_fd_sc_hd__fill_1
X_486_ _451_/A _486_/B _479_/A _485_/X _486_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
Xringosc.dstage\[5\].id.delaybuf1 ringosc.dstage\[5\].id.delaybuf1/A ringosc.dstage\[5\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_12_27 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.dstage\[1\].id.delayenb1 ringosc.dstage\[1\].id.delayenb0/A _444_/X ringosc.dstage\[1\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_18_209 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_245 VGND VPWR sky130_fd_sc_hd__decap_6
X_271_ _359_/B _264_/Y _276_/B _264_/Y _271_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_340_ _340_/A _340_/B _340_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_5_135 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_242 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_212 VGND VPWR sky130_fd_sc_hd__fill_2
X_469_ _423_/X _479_/A _469_/X VGND VPWR sky130_fd_sc_hd__or2_4
Xringosc.dstage\[1\].id.delayen0 ringosc.dstage\[1\].id.delayen0/A _392_/X ringosc.dstage\[1\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_23_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_70 VGND VPWR sky130_fd_sc_hd__decap_3
X_323_ _316_/C _306_/A _322_/Y _353_/A VGND VPWR sky130_fd_sc_hd__o21ai_4
X_254_ _431_/C _395_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_18_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_59 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_306_ _306_/A _318_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_27_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_123 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_167 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_90 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_27 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_15 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_207 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_1 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_184 VGND VPWR sky130_fd_sc_hd__decap_8
X_485_ _395_/D _413_/A _478_/B _389_/A _485_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_8_166 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_243 VGND VPWR sky130_fd_sc_hd__fill_1
X_270_ _249_/Y _264_/Y _250_/A _264_/Y _533_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_468_ _413_/X _450_/B _479_/A VGND VPWR sky130_fd_sc_hd__or2_4
Xringosc.dstage\[1\].id.delayen1 ringosc.dstage\[1\].id.delayen1/A _444_/X ringosc.dstage\[1\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
X_399_ _450_/A _398_/X _399_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_23_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_106 VGND VPWR sky130_fd_sc_hd__decap_6
Xringosc.dstage\[1\].id.delaybuf0 ringosc.dstage\[0\].id.delayen0/Z ringosc.dstage\[1\].id.delayenb0/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
X_322_ _522_/Q _321_/X _322_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
XFILLER_13_60 VGND VPWR sky130_fd_sc_hd__fill_1
X_253_ _253_/A _396_/C VGND VPWR sky130_fd_sc_hd__inv_8
Xringosc.dstage\[4\].id.delayint0 ringosc.dstage\[4\].id.delayen1/Z ringosc.dstage\[4\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_18_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_59 VGND VPWR sky130_fd_sc_hd__decap_4
X_305_ _305_/A _313_/D _306_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_40_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_80 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_39 VGND VPWR sky130_fd_sc_hd__decap_6
Xringosc.dstage\[9\].id.delayen0 ringosc.dstage\[9\].id.delayen0/A _421_/X ringosc.dstage\[9\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XPHY_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_105 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_149 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_171 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_219 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_2 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_84 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_163 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_93 VGND VPWR sky130_fd_sc_hd__decap_12
X_484_ _253_/A dco _262_/Y ext_trim[23] _484_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_8_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_70 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_81 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_233 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_59 VGND VPWR sky130_fd_sc_hd__fill_2
X_467_ dco ext_trim[18] _466_/X _467_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_536_ _536_/D _536_/Q _512_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_398_ _395_/X _397_/X _398_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_23_39 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[1\].id.delaybuf1 ringosc.dstage\[1\].id.delayenb0/A ringosc.dstage\[1\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_14_203 VGND VPWR sky130_fd_sc_hd__decap_8
X_252_ _252_/A _252_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_321_ _316_/C _306_/A _258_/A _318_/B _321_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_1_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_519_ _368_/X _519_/Q _506_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_34_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_304_ div[4] _299_/X _303_/X _313_/D VGND VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_29_27 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_161 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_150 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_139 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_70 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_106 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_180 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_249 VGND VPWR sky130_fd_sc_hd__fill_2
Xringosc.dstage\[9\].id.delayen1 ringosc.dstage\[9\].id.delayen1/A _483_/X ringosc.dstage\[9\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XPHY_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_139 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_72 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_164 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_242 VGND VPWR sky130_fd_sc_hd__fill_2
X_483_ dco ext_trim[22] _482_/X _483_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_32_93 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_223 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_149 VGND VPWR sky130_fd_sc_hd__decap_4
X_535_ _535_/D _246_/A _499_/A _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_17_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_215 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_226 VGND VPWR sky130_fd_sc_hd__decap_12
X_397_ _478_/A _397_/B _397_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_466_ _466_/A _465_/X _466_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_4_64 VGND VPWR sky130_fd_sc_hd__fill_1
X_251_ _369_/B _359_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_13_40 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_215 VGND VPWR sky130_fd_sc_hd__decap_12
X_320_ _320_/A _320_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_13_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_196 VGND VPWR sky130_fd_sc_hd__decap_12
X_518_ _371_/X _518_/Q _507_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_449_ dco ext_trim[15] _448_/X _449_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_303_ _243_/Y _244_/Y _297_/X _298_/X _303_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_1_76 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_126 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_137 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_148 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[0\].id.delayint0 ringosc.dstage\[0\].id.delayen1/Z ringosc.dstage\[0\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
Xringosc.iss.reseten0 ringosc.iss.const1/HI _266_/Y ringosc.ibufp00/A VGND VPWR sky130_fd_sc_hd__einvp_1
XFILLER_10_30 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_72 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_173 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_151 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_162 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_173 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_62 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_9 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_4 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_154 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_176 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_132 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_154 VGND VPWR sky130_fd_sc_hd__decap_12
X_482_ _478_/A _481_/X _429_/X _479_/D _482_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_7_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_39 VGND VPWR sky130_fd_sc_hd__decap_12
X_534_ _534_/D _534_/Q _491_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_465_ _478_/A _465_/B _464_/X _465_/D _465_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_32_238 VGND VPWR sky130_fd_sc_hd__decap_12
X_396_ _395_/A _396_/B _396_/C _396_/D _397_/B VGND VPWR sky130_fd_sc_hd__and4_4
Xringosc.dstage\[8\].id.delayenb0 ringosc.dstage\[8\].id.delayenb0/A _419_/X ringosc.dstage\[8\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_23_205 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_216 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_250_ _250_/A _250_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_13_96 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_93 VGND VPWR sky130_fd_sc_hd__fill_2
X_517_ _372_/X _369_/B _508_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_448_ _448_/A _447_/X _448_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_9_220 VGND VPWR sky130_fd_sc_hd__decap_12
X_379_ _395_/A _415_/B _396_/C _403_/D _478_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_11_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_302_ _302_/A _301_/X _302_/C _305_/A VGND VPWR sky130_fd_sc_hd__nor3_4
XFILLER_1_33 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_66 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_105 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_116 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_86 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_64 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_62 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_138 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_185 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_218 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.iss.delayint0 ringosc.iss.delayen1/Z ringosc.iss.delayen0/A VGND VPWR sky130_fd_sc_hd__clkinv_1
XPHY_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_163 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_5 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_100 VGND VPWR sky130_fd_sc_hd__decap_8
X_481_ _413_/A _478_/B _481_/C _481_/X VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_29_222 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_111 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_166 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_85 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_40 VGND VPWR sky130_fd_sc_hd__decap_6
X_533_ _533_/D _250_/A _492_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_464_ _413_/A _464_/B _464_/C _464_/X VGND VPWR sky130_fd_sc_hd__or3_4
Xringosc.dstage\[8\].id.delayenb1 ringosc.dstage\[8\].id.delayenb0/A _480_/X ringosc.dstage\[8\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
X_395_ _395_/A _396_/B _396_/C _395_/D _395_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_4_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_77 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_232 VGND VPWR sky130_fd_sc_hd__decap_12
X_516_ _263_/A _263_/B _509_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_447_ _413_/A _478_/B _488_/A _445_/Y _447_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_378_ _378_/A _403_/D VGND VPWR sky130_fd_sc_hd__inv_8
X_301_ div[3] _293_/B _292_/X _301_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_6_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_76 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_109 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_51 VGND VPWR sky130_fd_sc_hd__decap_8
Xringosc.dstage\[6\].id.delayen0 ringosc.dstage\[6\].id.delayen0/A _409_/X ringosc.dstage\[6\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_35_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_161 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_186 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_6 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_33 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_123 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_234 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_245 VGND VPWR sky130_fd_sc_hd__decap_6
X_480_ dco ext_trim[21] _479_/X _480_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_8_116 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_145 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_189 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_237 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_226 VGND VPWR sky130_fd_sc_hd__decap_4
X_532_ _271_/X _276_/B _493_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_394_ _382_/B _394_/B _450_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_463_ dco ext_trim[17] _462_/X _463_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_13_54 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_3 VGND VPWR sky130_fd_sc_hd__decap_6
X_515_ _514_/Q _263_/A _510_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_377_ _474_/D _377_/B _378_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_446_ _396_/C _446_/B _458_/D _488_/A VGND VPWR sky130_fd_sc_hd__nor3_4
Xringosc.dstage\[8\].id.delaybuf0 ringosc.dstage\[7\].id.delayen0/Z ringosc.dstage\[8\].id.delayenb0/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
Xringosc.dstage\[4\].id.delayenb0 ringosc.dstage\[4\].id.delaybuf0/X _407_/X ringosc.dstage\[4\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
X_300_ div[4] _299_/X _302_/A VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_1_57 VGND VPWR sky130_fd_sc_hd__decap_4
X_429_ _389_/A _450_/B _429_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_36_162 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[10\].id.delayen0 ringosc.dstage\[10\].id.delayen0/A _422_/X ringosc.dstage\[10\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_36_184 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_44 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_107 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_154 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_140 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_184 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_187 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[6\].id.delayen1 ringosc.dstage\[6\].id.delayen1/A _470_/X ringosc.dstage\[6\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_18_195 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_143 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_132 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_7 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_154 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_113 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_78 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_12 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_146 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_172 VGND VPWR sky130_fd_sc_hd__decap_8
X_531_ _272_/X _314_/C _494_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_462_ _454_/A _465_/D _460_/X _399_/X _462_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_393_ _478_/B _382_/A _393_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_13_44 VGND VPWR sky130_fd_sc_hd__fill_1
X_514_ osc _514_/Q _511_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_9_245 VGND VPWR sky130_fd_sc_hd__decap_6
X_376_ _376_/A _413_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_445_ _396_/C _445_/B _445_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
Xringosc.dstage\[8\].id.delaybuf1 ringosc.dstage\[8\].id.delayenb0/A ringosc.dstage\[8\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xringosc.dstage\[4\].id.delayenb1 ringosc.dstage\[4\].id.delaybuf0/X _463_/X ringosc.dstage\[4\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_6_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_32 VGND VPWR sky130_fd_sc_hd__decap_4
X_428_ _431_/C _415_/B _396_/C _378_/A _450_/B VGND VPWR sky130_fd_sc_hd__and4_4
X_359_ _249_/Y _359_/B _366_/B VGND VPWR sky130_fd_sc_hd__or2_4
Xringosc.dstage\[10\].id.delayen1 ringosc.dstage\[10\].id.delayen1/A _484_/X ringosc.dstage\[10\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_19_43 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_133 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_199 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_100 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_8 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_111 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_136 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_136 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_55 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_66 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_32 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_209 VGND VPWR sky130_fd_sc_hd__decap_12
X_530_ _530_/D _252_/A _495_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_17_206 VGND VPWR sky130_fd_sc_hd__decap_12
X_461_ _393_/X _461_/B _465_/D VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_40_231 VGND VPWR sky130_fd_sc_hd__decap_12
X_392_ dco ext_trim[1] _391_/X _392_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_4_121 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_231 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_146 VGND VPWR sky130_fd_sc_hd__decap_4
X_513_ _513_/A clockp[0] VGND VPWR sky130_fd_sc_hd__buf_2
X_444_ dco ext_trim[14] _443_/X _444_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_375_ _395_/A _415_/B _253_/A _376_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_6_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_77 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_15 VGND VPWR sky130_fd_sc_hd__decap_12
X_358_ _311_/B _320_/Y _357_/X _358_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_427_ _376_/A _426_/X _401_/Y dco ext_trim[13] _427_/X VGND VPWR sky130_fd_sc_hd__a32o_4
X_289_ _519_/Q _534_/Q _285_/X _289_/Y VGND VPWR sky130_fd_sc_hd__a21oi_4
Xringosc.dstage\[4\].id.delaybuf0 ringosc.dstage\[3\].id.delayen0/Z ringosc.dstage\[4\].id.delaybuf0/X
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_3_208 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[0\].id.delayenb0 ringosc.dstage\[0\].id.delayenb0/A _374_/X ringosc.dstage\[0\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_19_33 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_156 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_76 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_98 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[7\].id.delayint0 ringosc.dstage\[7\].id.delayen1/Z ringosc.dstage\[7\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_33_123 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_112 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_89 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_9 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_38_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_104 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_207 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_218 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_240 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_33 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_44 VGND VPWR sky130_fd_sc_hd__decap_6
X_460_ _460_/A _464_/C _457_/X _460_/D _460_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_391_ _413_/A _390_/X _391_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_40_243 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_177 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_48 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_15 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_35 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_22_243 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_103 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_32 VGND VPWR sky130_fd_sc_hd__decap_12
X_512_ _499_/A _512_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_13_243 VGND VPWR sky130_fd_sc_hd__fill_1
X_374_ ext_trim[0] dco _478_/A _374_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_443_ _448_/A _442_/X _443_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_5_80 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_195 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_3 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_27 VGND VPWR sky130_fd_sc_hd__decap_6
X_357_ _522_/Q _319_/A _357_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_426_ _395_/A _396_/B _253_/A _525_/Q _426_/X VGND VPWR sky130_fd_sc_hd__or4_4
X_288_ _284_/X _287_/X _284_/X _287_/X _293_/B VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_39_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_154 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_176 VGND VPWR sky130_fd_sc_hd__decap_8
Xringosc.dstage\[3\].id.delayen0 ringosc.dstage\[3\].id.delayen0/A _405_/X ringosc.dstage\[3\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
Xringosc.dstage\[0\].id.delayenb1 ringosc.dstage\[0\].id.delayenb0/A _427_/X ringosc.dstage\[0\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
Xringosc.dstage\[4\].id.delaybuf1 ringosc.dstage\[4\].id.delaybuf0/X ringosc.dstage\[4\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_19_89 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_132 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_121 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_132 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_102 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_113 VGND VPWR sky130_fd_sc_hd__decap_8
X_409_ dco ext_trim[6] _397_/X _409_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_2_81 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xringosc.iss.delayenb0 ringosc.iss.delayenb0/A ringosc.iss.ctrlen0/X ringosc.ibufp00/A
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_21_46 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_190 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_90 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_205 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_149 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_171 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_211 VGND VPWR sky130_fd_sc_hd__decap_3
X_390_ _478_/B _389_/X _390_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_4_101 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_189 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_145 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_511_ _499_/A _511_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_38_44 VGND VPWR sky130_fd_sc_hd__decap_12
X_373_ dco _373_/B _478_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_442_ _478_/B _486_/B _440_/Y _442_/D _442_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_39_163 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_141 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_46 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_56 VGND VPWR sky130_fd_sc_hd__decap_12
X_287_ _366_/A _285_/B _285_/X _286_/X _287_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_425_ dco ext_trim[12] _399_/X _425_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_356_ _320_/Y _322_/Y _355_/X _258_/A _320_/A _523_/D VGND VPWR sky130_fd_sc_hd__a32o_4
Xringosc.dstage\[3\].id.delayen1 ringosc.dstage\[3\].id.delayen1/A _455_/X ringosc.dstage\[3\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_42_125 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_199 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_100 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_188 VGND VPWR sky130_fd_sc_hd__decap_4
X_408_ dco ext_trim[5] _389_/X _408_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_339_ _320_/Y _338_/Y _337_/X _253_/A _320_/A _339_/X VGND VPWR sky130_fd_sc_hd__a32o_4
XPHY_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xringosc.iss.delayenb1 ringosc.iss.delayenb0/A _490_/X ringosc.iss.delayen1/Z VGND
+ VPWR sky130_fd_sc_hd__einvn_4
Xringosc.dstage\[0\].id.delaybuf0 ringosc.ibufp00/A ringosc.dstage\[0\].id.delayenb0/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_38_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_239 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[3\].id.delayint0 ringosc.dstage\[3\].id.delayen1/Z ringosc.dstage\[3\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_12_139 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_161 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_46 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_7_132 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_79 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_116 VGND VPWR sky130_fd_sc_hd__decap_6
X_510_ _499_/A _510_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_441_ _253_/A _525_/Q _395_/A _415_/B _486_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_38_56 VGND VPWR sky130_fd_sc_hd__decap_12
X_372_ _365_/C _361_/X _359_/B _314_/B _372_/X VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_13_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_36 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_58 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_68 VGND VPWR sky130_fd_sc_hd__decap_12
X_424_ dco ext_trim[11] _423_/X _424_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_286_ _249_/Y _250_/Y _275_/X _276_/Y _286_/X VGND VPWR sky130_fd_sc_hd__o22a_4
X_355_ _522_/Q _321_/X _355_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_36_123 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_156 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_167 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_178 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_211 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_170 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_338_ _338_/A _338_/B _338_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_407_ _390_/X _451_/A dco ext_trim[4] _407_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_269_ _366_/A _264_/Y _534_/Q _264_/Y _534_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_24_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_15 VGND VPWR sky130_fd_sc_hd__decap_8
Xringosc.dstage\[0\].id.delaybuf1 ringosc.dstage\[0\].id.delayenb0/A ringosc.dstage\[0\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_23_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_30_107 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_184 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_195 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_36 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.iss.delaybuf0 ringosc.iss.delayenb0/A ringosc.iss.delayen1/A VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_11_184 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_90 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_27 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_9 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_68 VGND VPWR sky130_fd_sc_hd__decap_12
X_371_ _371_/A _370_/X _371_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_440_ _396_/C _440_/B _440_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_0_150 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_15 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_209 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_354_ _320_/Y _348_/Y _353_/X _308_/B _320_/A _524_/D VGND VPWR sky130_fd_sc_hd__a32o_4
X_423_ _401_/A _411_/B _423_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_285_ _366_/A _285_/B _285_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_5_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_80 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_37 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_42_138 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_406_ _415_/C _396_/D _413_/A _451_/A VGND VPWR sky130_fd_sc_hd__o21a_4
X_337_ _338_/A _338_/B _337_/X VGND VPWR sky130_fd_sc_hd__or2_4
XPHY_80 VGND VPWR sky130_fd_sc_hd__decap_3
X_268_ _245_/Y _264_/Y _246_/A _264_/Y _535_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_37_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_82 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_108 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_72 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_19 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_203 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_370_ _366_/B _370_/B _264_/Y _370_/X VGND VPWR sky130_fd_sc_hd__and3_4
XFILLER_13_203 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_499_ _499_/A _499_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_24_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[0\].id.delayen0 ringosc.dstage\[0\].id.delayen0/A _374_/X ringosc.dstage\[0\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
X_284_ _365_/A _246_/A _283_/X _284_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_353_ _353_/A _353_/B _353_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_422_ dco ext_trim[10] _398_/X _422_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_5_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_136 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_147 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_18 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_27 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_106 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_147 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_139 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_81 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_267_ enable resetb _262_/Y _499_/A VGND VPWR sky130_fd_sc_hd__and3_4
X_336_ _253_/A _318_/B _396_/C _306_/A _338_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XPHY_70 VGND VPWR sky130_fd_sc_hd__decap_3
X_405_ dco ext_trim[3] _417_/D _405_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
Xringosc.dstage\[7\].id.delayenb0 ringosc.dstage\[7\].id.delaybuf1/A _418_/X ringosc.dstage\[7\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_32_161 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_194 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_139 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_172 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_319_ _319_/A _319_/B _320_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_20_120 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_231 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_27 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_245 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_71 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_215 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_208 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_185 VGND VPWR sky130_fd_sc_hd__fill_1
X_498_ _499_/A _498_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_39_123 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_27 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.dstage\[0\].id.delayen1 ringosc.dstage\[0\].id.delayen1/A _427_/X ringosc.dstage\[0\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
X_421_ dco ext_trim[9] _420_/X _421_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_283_ _245_/Y _246_/Y _283_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_352_ _320_/Y _351_/X _350_/Y _525_/Q _320_/A _352_/X VGND VPWR sky130_fd_sc_hd__a32o_4
XFILLER_30_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_118 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_104 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_148 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_203 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_82 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_71 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_60 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_129 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_71 VGND VPWR sky130_fd_sc_hd__decap_3
X_404_ _398_/X _403_/X _417_/D VGND VPWR sky130_fd_sc_hd__or2_4
XPHY_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_266_ enable resetb _266_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_335_ _340_/B _334_/Y _340_/A _318_/B _446_/B _338_/A VGND VPWR sky130_fd_sc_hd__a32o_4
Xringosc.dstage\[7\].id.delayenb1 ringosc.dstage\[7\].id.delaybuf1/A _476_/X ringosc.dstage\[7\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_23_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_184 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_162 VGND VPWR sky130_fd_sc_hd__decap_3
X_249_ _518_/Q _249_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_318_ _395_/A _318_/B _318_/C _319_/B VGND VPWR sky130_fd_sc_hd__nor3_4
XFILLER_42_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_110 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_165 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_121 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_243 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_213 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[8\].id.delayen0 ringosc.dstage\[8\].id.delayen0/A _419_/X ringosc.dstage\[8\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_16_213 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_71 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_38_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_13_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_497_ _499_/A _497_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_5_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_9 VGND VPWR sky130_fd_sc_hd__fill_1
X_351_ _325_/A _350_/B _351_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_420_ _415_/C _413_/A _390_/X _420_/X VGND VPWR sky130_fd_sc_hd__a21o_4
X_282_ _278_/X _281_/X _279_/Y _282_/Y VGND VPWR sky130_fd_sc_hd__nor3_4
XFILLER_5_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_50 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_182 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_215 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_83 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_50 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_83 VGND VPWR sky130_fd_sc_hd__decap_4
X_334_ _342_/A _334_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_61 VGND VPWR sky130_fd_sc_hd__decap_3
X_403_ _395_/A _396_/B _396_/C _403_/D _403_/X VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_72 VGND VPWR sky130_fd_sc_hd__decap_3
X_265_ _243_/Y _264_/Y _536_/Q _264_/Y _536_/D VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_2_32 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_54 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_119 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_3 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_141 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_196 VGND VPWR sky130_fd_sc_hd__decap_4
X_317_ _396_/C _474_/D _316_/X _318_/C VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_36_93 VGND VPWR sky130_fd_sc_hd__decap_6
X_248_ _534_/Q _285_/B VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_35_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_211 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[7\].id.delaybuf0 ringosc.dstage\[6\].id.delayen0/Z ringosc.dstage\[7\].id.delaybuf1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
Xringosc.dstage\[3\].id.delayenb0 ringosc.dstage\[3\].id.delaybuf1/A _405_/X ringosc.dstage\[3\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_20_133 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.dstage\[11\].id.delayint0 ringosc.dstage\[11\].id.delayen1/Z ringosc.dstage\[11\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_7_148 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_51 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[8\].id.delayen1 ringosc.dstage\[8\].id.delayen1/A _480_/X ringosc.dstage\[8\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XPHY_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_239 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_151 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_206 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_239 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_154 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_165 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_187 VGND VPWR sky130_fd_sc_hd__decap_12
X_496_ _499_/A _496_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_39_169 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_19 VGND VPWR sky130_fd_sc_hd__fill_1
X_350_ _325_/A _350_/B _350_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_281_ _281_/A _280_/X _281_/X VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_30_62 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_106 VGND VPWR sky130_fd_sc_hd__decap_4
X_479_ _479_/A _479_/B _479_/C _479_/D _479_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_27_117 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_2_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_106 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_84 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_197 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_264_ _314_/B _264_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_40 VGND VPWR sky130_fd_sc_hd__decap_3
X_402_ dco ext_trim[2] _401_/Y _402_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_25_51 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_51 VGND VPWR sky130_fd_sc_hd__decap_3
X_333_ _395_/A _318_/B _431_/C _306_/A _342_/A VGND VPWR sky130_fd_sc_hd__o22a_4
XPHY_62 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_94 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_11 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_186 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_120 VGND VPWR sky130_fd_sc_hd__decap_4
X_247_ _519_/Q _366_/A VGND VPWR sky130_fd_sc_hd__inv_8
X_316_ _396_/B _377_/B _316_/C _311_/B _316_/X VGND VPWR sky130_fd_sc_hd__or4_4
Xringosc.dstage\[7\].id.delaybuf1 ringosc.dstage\[7\].id.delaybuf1/A ringosc.dstage\[7\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_28_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_223 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_245 VGND VPWR sky130_fd_sc_hd__decap_6
Xringosc.dstage\[3\].id.delayenb1 ringosc.dstage\[3\].id.delaybuf1/A _455_/X ringosc.dstage\[3\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_7_138 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_101 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_123 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_32 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_215 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_163 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_133 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_177 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_199 VGND VPWR sky130_fd_sc_hd__decap_12
X_495_ _499_/A _495_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_10_3 VGND VPWR sky130_fd_sc_hd__decap_6
X_280_ _369_/B _276_/B _276_/Y _280_/X VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_29_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_39_94 VGND VPWR sky130_fd_sc_hd__decap_4
X_478_ _478_/A _478_/B _479_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_35_184 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_2_239 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_30 VGND VPWR sky130_fd_sc_hd__decap_3
X_401_ _401_/A _401_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_26_151 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_85 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_121 VGND VPWR sky130_fd_sc_hd__fill_1
X_263_ _263_/A _263_/B _314_/B VGND VPWR sky130_fd_sc_hd__xor2_4
XPHY_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_41 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VPWR sky130_fd_sc_hd__decap_3
X_332_ _396_/B _306_/A _415_/B _318_/B _340_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XPHY_63 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_74 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_89 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_132 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_23_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_76 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_154 VGND VPWR sky130_fd_sc_hd__decap_8
X_246_ _246_/A _246_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_315_ _313_/Y _315_/B _315_/C _319_/A VGND VPWR sky130_fd_sc_hd__or3_4
XFILLER_37_235 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_146 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_11_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_135 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_161 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_219 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[3\].id.delaybuf0 ringosc.dstage\[2\].id.delayen0/Z ringosc.dstage\[3\].id.delaybuf1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_16_205 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_75 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xringosc.dstage\[6\].id.delayint0 ringosc.dstage\[6\].id.delayen1/Z ringosc.dstage\[6\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_3_175 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_219 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_145 VGND VPWR sky130_fd_sc_hd__fill_2
X_494_ _499_/A _494_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_39_116 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_127 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_32 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_76 VGND VPWR sky130_fd_sc_hd__decap_3
Xringosc.ibufp10 ringosc.ibufp10/A ringosc.ibufp11/A VGND VPWR sky130_fd_sc_hd__clkinv_2
XFILLER_30_97 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_51 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_62 VGND VPWR sky130_fd_sc_hd__decap_12
X_477_ _387_/B _477_/B _479_/D VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_35_174 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_20 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VPWR sky130_fd_sc_hd__decap_3
X_400_ _393_/X _399_/X _401_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_331_ _325_/Y _458_/D _353_/A _318_/B _309_/A _340_/A VGND VPWR sky130_fd_sc_hd__a32o_4
XPHY_53 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_64 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_177 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_41_155 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_74 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_262_ dco _262_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_75 VGND VPWR sky130_fd_sc_hd__decap_3
X_529_ _274_/X _314_/D _496_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_17_196 VGND VPWR sky130_fd_sc_hd__decap_6
X_314_ _252_/A _314_/B _314_/C _314_/D _315_/B VGND VPWR sky130_fd_sc_hd__nand4_4
X_245_ _365_/A _245_/Y VGND VPWR sky130_fd_sc_hd__inv_8
Xringosc.dstage\[5\].id.delayen0 ringosc.dstage\[5\].id.delayen0/A _408_/X ringosc.ibufp10/A
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_28_225 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_32 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_228 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_23 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_78 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_173 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_3 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[3\].id.delaybuf1 ringosc.dstage\[3\].id.delaybuf1/A ringosc.dstage\[3\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_16_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_54 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_250 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_493_ _499_/A _493_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_28_53 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_202 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_161 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_194 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_44 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_88 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.ibufp11 ringosc.ibufp11/A clockp[1] VGND VPWR sky130_fd_sc_hd__clkinv_8
Xringosc.ibufp00 ringosc.ibufp00/A ringosc.ibufp01/A VGND VPWR sky130_fd_sc_hd__clkinv_2
XFILLER_30_32 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_150 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_74 VGND VPWR sky130_fd_sc_hd__decap_12
X_476_ dco ext_trim[20] _475_/X _476_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_35_120 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_197 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_10 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_21 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_32 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VPWR sky130_fd_sc_hd__decap_3
X_330_ _330_/A _329_/A _458_/D VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_25_87 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_54 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_76 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_86 VGND VPWR sky130_fd_sc_hd__decap_8
X_261_ div[0] _281_/A VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_17_153 VGND VPWR sky130_fd_sc_hd__decap_4
X_459_ _395_/A _396_/B _253_/A _396_/D _464_/C VGND VPWR sky130_fd_sc_hd__and4_4
X_528_ _339_/X _253_/A _497_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_313_ _294_/X _312_/Y _302_/A _313_/D _313_/Y VGND VPWR sky130_fd_sc_hd__nor4_4
X_244_ _536_/Q _244_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_14_189 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_104 VGND VPWR sky130_fd_sc_hd__decap_6
Xringosc.dstage\[5\].id.delayen1 ringosc.dstage\[5\].id.delayen1/A _467_/X ringosc.dstage\[5\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_28_237 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_159 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_77 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_88 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_215 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_207 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_185 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_218 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_99 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_155 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_100 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_91 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_125 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_32 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_65 VGND VPWR sky130_fd_sc_hd__fill_1
X_492_ _499_/A _492_/X VGND VPWR sky130_fd_sc_hd__buf_1
Xringosc.dstage\[2\].id.delayint0 ringosc.dstage\[2\].id.delayen1/Z ringosc.dstage\[2\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_14_56 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.ibufp01 ringosc.ibufp01/A _513_/A VGND VPWR sky130_fd_sc_hd__clkinv_8
XFILLER_29_184 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_86 VGND VPWR sky130_fd_sc_hd__fill_1
X_475_ _486_/B _474_/X _472_/X _469_/X _475_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_35_132 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_11 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_260_ div[2] _291_/A VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_22 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_33 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_33 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_132 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_143 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_154 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_55 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_77 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_220 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_132 VGND VPWR sky130_fd_sc_hd__decap_4
X_527_ _344_/X _431_/C _498_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_458_ _395_/A _396_/B _253_/A _458_/D _460_/A VGND VPWR sky130_fd_sc_hd__nor4_4
X_389_ _389_/A _387_/X _389_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_11_57 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_32 VGND VPWR sky130_fd_sc_hd__decap_12
X_312_ _281_/A _280_/X _282_/Y _312_/Y VGND VPWR sky130_fd_sc_hd__o21ai_4
X_243_ _365_/C _243_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_28_249 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_7_109 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_230 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[11\].id.delayenb0 ringosc.dstage\[11\].id.delaybuf0/X _424_/X ringosc.iss.delayenb0/A
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_6_131 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_197 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_3 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_491_ _499_/A _491_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_8_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_26 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_5_15 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_185 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_14_68 VGND VPWR sky130_fd_sc_hd__decap_8
X_474_ _431_/C _396_/B _253_/A _474_/D _474_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_35_144 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_155 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_91 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_12 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_136 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_23 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_45 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_199 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_56 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_78 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_27 VGND VPWR sky130_fd_sc_hd__decap_4
X_526_ _346_/X _415_/B _499_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_457_ _395_/A _415_/B _253_/A _378_/A _457_/X VGND VPWR sky130_fd_sc_hd__and4_4
X_388_ _387_/X _388_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XFILLER_23_136 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_44 VGND VPWR sky130_fd_sc_hd__decap_12
X_311_ _316_/C _311_/B _373_/B _318_/B _315_/C VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_22_180 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_206 VGND VPWR sky130_fd_sc_hd__fill_1
X_509_ _499_/A _509_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_9_184 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_191 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_250 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_242 VGND VPWR sky130_fd_sc_hd__decap_6
Xringosc.dstage\[11\].id.delayenb1 ringosc.dstage\[11\].id.delaybuf0/X _487_/X ringosc.dstage\[11\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_8_59 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_35 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_135 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_231 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_71 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_212 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_91 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_116 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_227 VGND VPWR sky130_fd_sc_hd__decap_12
X_490_ dco ext_trim[25] _489_/X _490_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_12_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_208 VGND VPWR sky130_fd_sc_hd__decap_12
X_473_ _472_/X _473_/Y VGND VPWR sky130_fd_sc_hd__inv_8
XPHY_13 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_167 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_178 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_115 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_79 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_3 VGND VPWR sky130_fd_sc_hd__decap_6
X_525_ _352_/X _525_/Q _500_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_456_ _456_/A _456_/B _460_/D VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_32_126 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_192 VGND VPWR sky130_fd_sc_hd__decap_4
X_387_ _478_/A _387_/B _387_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_31_181 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_148 VGND VPWR sky130_fd_sc_hd__decap_4
X_310_ _395_/A _396_/B _415_/C _396_/C _373_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_36_56 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[2\].id.delayen0 ringosc.dstage\[2\].id.delayen0/A _402_/X ringosc.dstage\[2\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
Xringosc.iss.const1 ringosc.iss.const1/HI ringosc.iss.const1/LO VGND VPWR sky130_fd_sc_hd__conb_1
X_508_ _499_/A _508_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_439_ _395_/A _415_/B _309_/A _446_/B _330_/A _440_/B VGND VPWR sky130_fd_sc_hd__o32a_4
XFILLER_9_196 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_218 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_111 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_210 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_243 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_24_232 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_79 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_147 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_243 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[11\].id.delaybuf0 ringosc.dstage\[10\].id.delayen0/Z ringosc.dstage\[11\].id.delaybuf0/X
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_30_213 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[6\].id.delayenb0 ringosc.dstage\[6\].id.delaybuf1/A _409_/X ringosc.dstage\[6\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
XFILLER_2_191 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_224 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_5_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_121 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_143 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_121 VGND VPWR sky130_fd_sc_hd__fill_1
X_472_ _481_/C _477_/B _472_/X VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_20_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_93 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_60 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_14 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_69 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_168 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_179 VGND VPWR sky130_fd_sc_hd__decap_4
X_524_ _524_/D _308_/B _501_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_386_ _394_/B _464_/B _387_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_32_105 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_138 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_149 VGND VPWR sky130_fd_sc_hd__decap_4
X_455_ dco ext_trim[16] _454_/X _455_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_23_105 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.dstage\[2\].id.delayen1 ringosc.dstage\[2\].id.delayen1/A _449_/X ringosc.dstage\[2\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_36_68 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_193 VGND VPWR sky130_fd_sc_hd__decap_4
X_369_ _518_/Q _369_/B _370_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_9_131 VGND VPWR sky130_fd_sc_hd__fill_2
X_507_ _499_/A _507_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_438_ _330_/A _413_/A _481_/C _437_/X _442_/D VGND VPWR sky130_fd_sc_hd__a211o_4
XFILLER_3_50 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_208 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_211 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_241 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_244 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xringosc.dstage\[11\].id.delaybuf1 ringosc.dstage\[11\].id.delaybuf0/X ringosc.dstage\[11\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
Xringosc.dstage\[6\].id.delayenb1 ringosc.dstage\[6\].id.delaybuf1/A _470_/X ringosc.dstage\[6\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_17_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_236 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_91 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_177 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_100 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_133 VGND VPWR sky130_fd_sc_hd__decap_8
X_471_ _465_/B _464_/C _477_/B VGND VPWR sky130_fd_sc_hd__or2_4
XPHY_15 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_59 VGND VPWR sky130_fd_sc_hd__decap_3
Xringosc.iss.delayen0 ringosc.iss.delayen0/A _425_/X ringosc.ibufp00/A VGND VPWR sky130_fd_sc_hd__einvp_2
X_523_ _523_/D _258_/A _502_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_40_161 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_70 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_15_81 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_92 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_191 VGND VPWR sky130_fd_sc_hd__decap_8
X_385_ _253_/A _446_/B _458_/D _464_/B VGND VPWR sky130_fd_sc_hd__nor3_4
X_454_ _454_/A _454_/B _398_/X _466_/A _454_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_16_191 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_17 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_161 VGND VPWR sky130_fd_sc_hd__decap_6
X_506_ _499_/A _506_/X VGND VPWR sky130_fd_sc_hd__buf_1
XFILLER_26_80 VGND VPWR sky130_fd_sc_hd__decap_12
X_368_ _371_/A _368_/B _368_/X VGND VPWR sky130_fd_sc_hd__or2_4
X_299_ _297_/X _298_/X _297_/X _298_/X _299_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
X_437_ _431_/C _396_/B _396_/C _396_/D _437_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_3_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_146 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_93 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_223 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_27 VGND VPWR sky130_fd_sc_hd__decap_8
XPHY_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_59 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_15_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_30_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_63 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_215 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[2\].id.delayenb0 ringosc.dstage\[2\].id.delaybuf1/A _402_/X ringosc.dstage\[2\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_8
Xringosc.dstage\[6\].id.delaybuf0 ringosc.ibufp10/A ringosc.dstage\[6\].id.delaybuf1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
XFILLER_38_189 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_123 VGND VPWR sky130_fd_sc_hd__fill_1
X_470_ dco ext_trim[19] _469_/X _470_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
Xringosc.dstage\[10\].id.delayint0 ringosc.dstage\[10\].id.delayen1/Z ringosc.dstage\[10\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
Xringosc.dstage\[9\].id.delayint0 ringosc.dstage\[9\].id.delayen1/Z ringosc.dstage\[9\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_20_71 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_93 VGND VPWR sky130_fd_sc_hd__fill_2
XPHY_16 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_49 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_27 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_192 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_15 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.iss.delayen1 ringosc.iss.delayen1/A _490_/X ringosc.iss.delayen1/Z VGND VPWR
+ sky130_fd_sc_hd__einvp_2
X_522_ _358_/Y _522_/Q _503_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_453_ _393_/X _456_/B _454_/B VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_32_118 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_60 VGND VPWR sky130_fd_sc_hd__fill_1
X_384_ _253_/A _445_/B _394_/B VGND VPWR sky130_fd_sc_hd__nor2_4
XFILLER_23_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_29 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_162 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_173 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_184 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_140 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_100 VGND VPWR sky130_fd_sc_hd__decap_4
X_505_ _499_/A _505_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_436_ _461_/B _435_/X _481_/C VGND VPWR sky130_fd_sc_hd__or2_4
X_367_ _314_/B _367_/B _367_/C _368_/B VGND VPWR sky130_fd_sc_hd__nor3_4
X_298_ _245_/Y _246_/Y _283_/X _287_/X _298_/X VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_3_74 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_30 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_210 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_125 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_202 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_235 VGND VPWR sky130_fd_sc_hd__decap_8
X_419_ dco ext_trim[8] _388_/Y _419_/X VGND VPWR sky130_fd_sc_hd__a21o_4
XFILLER_24_224 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_202 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_205 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_60 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_97 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_62 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_38 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_227 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_220 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[6\].id.delaybuf1 ringosc.dstage\[6\].id.delaybuf1/A ringosc.dstage\[6\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_22_3 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[2\].id.delayenb1 ringosc.dstage\[2\].id.delaybuf1/A _449_/X ringosc.dstage\[2\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvn_4
XFILLER_39_15 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_59 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_113 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_201 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_83 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_52 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_85 VGND VPWR sky130_fd_sc_hd__decap_6
XPHY_17 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_108 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_27 VGND VPWR sky130_fd_sc_hd__decap_12
XPHY_39 VGND VPWR sky130_fd_sc_hd__decap_3
X_521_ _521_/D _365_/C _504_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
X_383_ _431_/C _396_/B _309_/A _446_/B _378_/A _445_/B VGND VPWR sky130_fd_sc_hd__o32a_4
X_452_ _525_/Q _413_/A _456_/B VGND VPWR sky130_fd_sc_hd__and2_4
XFILLER_40_185 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_93 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_16_182 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_130 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_141 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_36_27 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_22_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_123 VGND VPWR sky130_fd_sc_hd__decap_8
X_504_ _499_/A _504_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_366_ _366_/A _366_/B _367_/C VGND VPWR sky130_fd_sc_hd__and2_4
X_435_ _395_/A _415_/B _253_/A _474_/D _435_/X VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_9_156 VGND VPWR sky130_fd_sc_hd__decap_12
X_297_ _243_/Y _244_/Y _243_/Y _244_/Y _297_/X VGND VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_36_222 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_222 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_100 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_166 VGND VPWR sky130_fd_sc_hd__decap_12
X_418_ dco ext_trim[7] _417_/X _418_/X VGND VPWR sky130_fd_sc_hd__a21bo_4
X_349_ _377_/B _306_/A _348_/Y _350_/B VGND VPWR sky130_fd_sc_hd__o21a_4
XFILLER_24_203 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_118 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_239 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_83 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_74 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_239 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.iss.ctrlen0 _266_/Y _425_/X ringosc.iss.ctrlen0/X VGND VPWR sky130_fd_sc_hd__or2_2
XFILLER_20_250 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_72 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_7_232 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_93 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_15_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_169 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_27 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_158 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_29_169 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_180 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_191 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_213 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_18 VGND VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_106 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_34_161 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_172 VGND VPWR sky130_fd_sc_hd__decap_4
Xringosc.dstage\[2\].id.delaybuf0 ringosc.dstage\[1\].id.delayen0/Z ringosc.dstage\[2\].id.delaybuf1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_2
X_520_ _520_/D _365_/A _505_/X _513_/A VGND VPWR sky130_fd_sc_hd__dfrtp_4
XFILLER_15_62 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_161 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_172 VGND VPWR sky130_fd_sc_hd__decap_8
X_451_ _451_/A _465_/B _454_/A VGND VPWR sky130_fd_sc_hd__or2_4
X_382_ _382_/A _382_/B _389_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_31_50 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_83 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[5\].id.delayint0 ringosc.dstage\[5\].id.delayen1/Z ringosc.dstage\[5\].id.delayen0/A
+ VGND VPWR sky130_fd_sc_hd__clkinv_1
XFILLER_39_231 VGND VPWR sky130_fd_sc_hd__decap_12
X_503_ _499_/A _503_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_296_ _278_/X _282_/Y _295_/Y _302_/C VGND VPWR sky130_fd_sc_hd__o21a_4
X_365_ _365_/A _367_/B _365_/C _264_/Y _371_/A VGND VPWR sky130_fd_sc_hd__and4_4
X_434_ _395_/A _396_/B _253_/A _525_/Q _461_/B VGND VPWR sky130_fd_sc_hd__and4_4
XFILLER_9_168 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_234 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_190 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_178 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_105 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_18_201 VGND VPWR sky130_fd_sc_hd__fill_1
X_279_ div[1] _277_/X _279_/Y VGND VPWR sky130_fd_sc_hd__nor2_4
X_348_ _353_/A _353_/B _348_/Y VGND VPWR sky130_fd_sc_hd__nand2_4
X_417_ _417_/A _417_/B _479_/C _417_/D _417_/X VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_24_215 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_62 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_152 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_53 VGND VPWR sky130_fd_sc_hd__decap_8
Xringosc.dstage\[7\].id.delayen0 ringosc.dstage\[7\].id.delayen0/A _418_/X ringosc.dstage\[7\].id.delayen0/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_38_115 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_148 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_39_39 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_41 VGND VPWR sky130_fd_sc_hd__decap_4
XPHY_19 VGND VPWR sky130_fd_sc_hd__decap_3
Xringosc.dstage\[2\].id.delaybuf1 ringosc.dstage\[2\].id.delaybuf1/A ringosc.dstage\[2\].id.delayen1/A
+ VGND VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_17_107 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_118 VGND VPWR sky130_fd_sc_hd__decap_4
X_381_ _395_/A _415_/B _396_/C _396_/D _382_/B VGND VPWR sky130_fd_sc_hd__and4_4
X_450_ _450_/A _450_/B _466_/A VGND VPWR sky130_fd_sc_hd__or2_4
XFILLER_16_173 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_110 VGND VPWR sky130_fd_sc_hd__fill_1
XPHY_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_39_243 VGND VPWR sky130_fd_sc_hd__fill_1
X_502_ _499_/A _502_/X VGND VPWR sky130_fd_sc_hd__buf_1
X_433_ _478_/A _465_/B _387_/B _429_/X _448_/A VGND VPWR sky130_fd_sc_hd__or4_4
XFILLER_42_94 VGND VPWR sky130_fd_sc_hd__decap_12
X_295_ _294_/X _295_/Y VGND VPWR sky130_fd_sc_hd__inv_8
X_364_ _243_/Y _361_/X _363_/Y _520_/D VGND VPWR sky130_fd_sc_hd__a21oi_4
XFILLER_13_154 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_88 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_213 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_246 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_249 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_5_3 VGND VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_75 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_18_213 VGND VPWR sky130_fd_sc_hd__fill_1
X_416_ _478_/B _415_/X _417_/B VGND VPWR sky130_fd_sc_hd__or2_4
X_278_ div[1] _277_/X _278_/X VGND VPWR sky130_fd_sc_hd__and2_4
X_347_ _377_/B _306_/A _308_/B _318_/B _353_/B VGND VPWR sky130_fd_sc_hd__o22a_4
XFILLER_38_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_52 VGND VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_74 VGND VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_56 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67 VGND VPWR sky130_fd_sc_hd__fill_1
Xringosc.dstage\[11\].id.delayen0 ringosc.dstage\[11\].id.delayen0/A _424_/X ringosc.iss.delayenb0/A
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_9_21 VGND VPWR sky130_fd_sc_hd__decap_12
Xringosc.dstage\[7\].id.delayen1 ringosc.dstage\[7\].id.delayen1/A _476_/X ringosc.dstage\[7\].id.delayen1/Z
+ VGND VPWR sky130_fd_sc_hd__einvp_2
XFILLER_18_85 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_245 VGND VPWR sky130_fd_sc_hd__decap_6
XFILLER_38_127 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_160 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_215 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_62 VGND VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_108 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_3 VGND VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_119 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_25_130 VGND VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_199 VGND VPWR sky130_fd_sc_hd__decap_12
X_380_ _395_/A _415_/B _396_/C _395_/D _382_/A VGND VPWR sky130_fd_sc_hd__and4_4
XPHY_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
.ends
