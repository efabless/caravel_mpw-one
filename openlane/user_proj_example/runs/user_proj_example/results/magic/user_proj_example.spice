* NGSPICE file created from user_proj_example.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_12 abstract view
.subckt sky130_fd_sc_hd__decap_12 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_4 abstract view
.subckt sky130_fd_sc_hd__dfxtp_4 D Q CLK VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A Y VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__conb_1 abstract view
.subckt sky130_fd_sc_hd__conb_1 HI LO VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_4 abstract view
.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_4 abstract view
.subckt sky130_fd_sc_hd__and3_4 A B C X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_4 abstract view
.subckt sky130_fd_sc_hd__or2_4 A B X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_4 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_4 abstract view
.subckt sky130_fd_sc_hd__or4_4 A B C D X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_4 abstract view
.subckt sky130_fd_sc_hd__nor2_4 A B Y VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_4 abstract view
.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_4 abstract view
.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_4 abstract view
.subckt sky130_fd_sc_hd__nand2_4 A B Y VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a32o_4 abstract view
.subckt sky130_fd_sc_hd__a32o_4 A1 A2 A3 B1 B2 X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_4 abstract view
.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 Y VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_4 abstract view
.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_4 abstract view
.subckt sky130_fd_sc_hd__and2_4 A B X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_4 abstract view
.subckt sky130_fd_sc_hd__or3_4 A B C X VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A X VGND VNB VPB VPWR
.ends

.subckt user_proj_example io_in[0] io_in[10] io_in[11] io_in[12] io_in[13] io_in[14]
+ io_in[15] io_in[16] io_in[17] io_in[18] io_in[19] io_in[1] io_in[20] io_in[21] io_in[22]
+ io_in[23] io_in[24] io_in[25] io_in[26] io_in[27] io_in[28] io_in[29] io_in[2] io_in[30]
+ io_in[31] io_in[32] io_in[33] io_in[34] io_in[35] io_in[36] io_in[37] io_in[3] io_in[4]
+ io_in[5] io_in[6] io_in[7] io_in[8] io_in[9] io_oeb[0] io_oeb[10] io_oeb[11] io_oeb[12]
+ io_oeb[13] io_oeb[14] io_oeb[15] io_oeb[16] io_oeb[17] io_oeb[18] io_oeb[19] io_oeb[1]
+ io_oeb[20] io_oeb[21] io_oeb[22] io_oeb[23] io_oeb[24] io_oeb[25] io_oeb[26] io_oeb[27]
+ io_oeb[28] io_oeb[29] io_oeb[2] io_oeb[30] io_oeb[31] io_oeb[32] io_oeb[33] io_oeb[34]
+ io_oeb[35] io_oeb[36] io_oeb[37] io_oeb[3] io_oeb[4] io_oeb[5] io_oeb[6] io_oeb[7]
+ io_oeb[8] io_oeb[9] io_out[0] io_out[10] io_out[11] io_out[12] io_out[13] io_out[14]
+ io_out[15] io_out[16] io_out[17] io_out[18] io_out[19] io_out[1] io_out[20] io_out[21]
+ io_out[22] io_out[23] io_out[24] io_out[25] io_out[26] io_out[27] io_out[28] io_out[29]
+ io_out[2] io_out[30] io_out[31] io_out[32] io_out[33] io_out[34] io_out[35] io_out[36]
+ io_out[37] io_out[3] io_out[4] io_out[5] io_out[6] io_out[7] io_out[8] io_out[9]
+ la_data_in[0] la_data_in[100] la_data_in[101] la_data_in[102] la_data_in[103] la_data_in[104]
+ la_data_in[105] la_data_in[106] la_data_in[107] la_data_in[108] la_data_in[109]
+ la_data_in[10] la_data_in[110] la_data_in[111] la_data_in[112] la_data_in[113] la_data_in[114]
+ la_data_in[115] la_data_in[116] la_data_in[117] la_data_in[118] la_data_in[119]
+ la_data_in[11] la_data_in[120] la_data_in[121] la_data_in[122] la_data_in[123] la_data_in[124]
+ la_data_in[125] la_data_in[126] la_data_in[127] la_data_in[12] la_data_in[13] la_data_in[14]
+ la_data_in[15] la_data_in[16] la_data_in[17] la_data_in[18] la_data_in[19] la_data_in[1]
+ la_data_in[20] la_data_in[21] la_data_in[22] la_data_in[23] la_data_in[24] la_data_in[25]
+ la_data_in[26] la_data_in[27] la_data_in[28] la_data_in[29] la_data_in[2] la_data_in[30]
+ la_data_in[31] la_data_in[32] la_data_in[33] la_data_in[34] la_data_in[35] la_data_in[36]
+ la_data_in[37] la_data_in[38] la_data_in[39] la_data_in[3] la_data_in[40] la_data_in[41]
+ la_data_in[42] la_data_in[43] la_data_in[44] la_data_in[45] la_data_in[46] la_data_in[47]
+ la_data_in[48] la_data_in[49] la_data_in[4] la_data_in[50] la_data_in[51] la_data_in[52]
+ la_data_in[53] la_data_in[54] la_data_in[55] la_data_in[56] la_data_in[57] la_data_in[58]
+ la_data_in[59] la_data_in[5] la_data_in[60] la_data_in[61] la_data_in[62] la_data_in[63]
+ la_data_in[64] la_data_in[65] la_data_in[66] la_data_in[67] la_data_in[68] la_data_in[69]
+ la_data_in[6] la_data_in[70] la_data_in[71] la_data_in[72] la_data_in[73] la_data_in[74]
+ la_data_in[75] la_data_in[76] la_data_in[77] la_data_in[78] la_data_in[79] la_data_in[7]
+ la_data_in[80] la_data_in[81] la_data_in[82] la_data_in[83] la_data_in[84] la_data_in[85]
+ la_data_in[86] la_data_in[87] la_data_in[88] la_data_in[89] la_data_in[8] la_data_in[90]
+ la_data_in[91] la_data_in[92] la_data_in[93] la_data_in[94] la_data_in[95] la_data_in[96]
+ la_data_in[97] la_data_in[98] la_data_in[99] la_data_in[9] la_data_out[0] la_data_out[100]
+ la_data_out[101] la_data_out[102] la_data_out[103] la_data_out[104] la_data_out[105]
+ la_data_out[106] la_data_out[107] la_data_out[108] la_data_out[109] la_data_out[10]
+ la_data_out[110] la_data_out[111] la_data_out[112] la_data_out[113] la_data_out[114]
+ la_data_out[115] la_data_out[116] la_data_out[117] la_data_out[118] la_data_out[119]
+ la_data_out[11] la_data_out[120] la_data_out[121] la_data_out[122] la_data_out[123]
+ la_data_out[124] la_data_out[125] la_data_out[126] la_data_out[127] la_data_out[12]
+ la_data_out[13] la_data_out[14] la_data_out[15] la_data_out[16] la_data_out[17]
+ la_data_out[18] la_data_out[19] la_data_out[1] la_data_out[20] la_data_out[21] la_data_out[22]
+ la_data_out[23] la_data_out[24] la_data_out[25] la_data_out[26] la_data_out[27]
+ la_data_out[28] la_data_out[29] la_data_out[2] la_data_out[30] la_data_out[31] la_data_out[32]
+ la_data_out[33] la_data_out[34] la_data_out[35] la_data_out[36] la_data_out[37]
+ la_data_out[38] la_data_out[39] la_data_out[3] la_data_out[40] la_data_out[41] la_data_out[42]
+ la_data_out[43] la_data_out[44] la_data_out[45] la_data_out[46] la_data_out[47]
+ la_data_out[48] la_data_out[49] la_data_out[4] la_data_out[50] la_data_out[51] la_data_out[52]
+ la_data_out[53] la_data_out[54] la_data_out[55] la_data_out[56] la_data_out[57]
+ la_data_out[58] la_data_out[59] la_data_out[5] la_data_out[60] la_data_out[61] la_data_out[62]
+ la_data_out[63] la_data_out[64] la_data_out[65] la_data_out[66] la_data_out[67]
+ la_data_out[68] la_data_out[69] la_data_out[6] la_data_out[70] la_data_out[71] la_data_out[72]
+ la_data_out[73] la_data_out[74] la_data_out[75] la_data_out[76] la_data_out[77]
+ la_data_out[78] la_data_out[79] la_data_out[7] la_data_out[80] la_data_out[81] la_data_out[82]
+ la_data_out[83] la_data_out[84] la_data_out[85] la_data_out[86] la_data_out[87]
+ la_data_out[88] la_data_out[89] la_data_out[8] la_data_out[90] la_data_out[91] la_data_out[92]
+ la_data_out[93] la_data_out[94] la_data_out[95] la_data_out[96] la_data_out[97]
+ la_data_out[98] la_data_out[99] la_data_out[9] la_oen[0] la_oen[100] la_oen[101]
+ la_oen[102] la_oen[103] la_oen[104] la_oen[105] la_oen[106] la_oen[107] la_oen[108]
+ la_oen[109] la_oen[10] la_oen[110] la_oen[111] la_oen[112] la_oen[113] la_oen[114]
+ la_oen[115] la_oen[116] la_oen[117] la_oen[118] la_oen[119] la_oen[11] la_oen[120]
+ la_oen[121] la_oen[122] la_oen[123] la_oen[124] la_oen[125] la_oen[126] la_oen[127]
+ la_oen[12] la_oen[13] la_oen[14] la_oen[15] la_oen[16] la_oen[17] la_oen[18] la_oen[19]
+ la_oen[1] la_oen[20] la_oen[21] la_oen[22] la_oen[23] la_oen[24] la_oen[25] la_oen[26]
+ la_oen[27] la_oen[28] la_oen[29] la_oen[2] la_oen[30] la_oen[31] la_oen[32] la_oen[33]
+ la_oen[34] la_oen[35] la_oen[36] la_oen[37] la_oen[38] la_oen[39] la_oen[3] la_oen[40]
+ la_oen[41] la_oen[42] la_oen[43] la_oen[44] la_oen[45] la_oen[46] la_oen[47] la_oen[48]
+ la_oen[49] la_oen[4] la_oen[50] la_oen[51] la_oen[52] la_oen[53] la_oen[54] la_oen[55]
+ la_oen[56] la_oen[57] la_oen[58] la_oen[59] la_oen[5] la_oen[60] la_oen[61] la_oen[62]
+ la_oen[63] la_oen[64] la_oen[65] la_oen[66] la_oen[67] la_oen[68] la_oen[69] la_oen[6]
+ la_oen[70] la_oen[71] la_oen[72] la_oen[73] la_oen[74] la_oen[75] la_oen[76] la_oen[77]
+ la_oen[78] la_oen[79] la_oen[7] la_oen[80] la_oen[81] la_oen[82] la_oen[83] la_oen[84]
+ la_oen[85] la_oen[86] la_oen[87] la_oen[88] la_oen[89] la_oen[8] la_oen[90] la_oen[91]
+ la_oen[92] la_oen[93] la_oen[94] la_oen[95] la_oen[96] la_oen[97] la_oen[98] la_oen[99]
+ la_oen[9] vccd1 vccd2 vdda1 vdda2 vssa1 vssa2 vssd1 vssd2 wb_clk_i wb_rst_i wbs_ack_o
+ wbs_adr_i[0] wbs_adr_i[10] wbs_adr_i[11] wbs_adr_i[12] wbs_adr_i[13] wbs_adr_i[14]
+ wbs_adr_i[15] wbs_adr_i[16] wbs_adr_i[17] wbs_adr_i[18] wbs_adr_i[19] wbs_adr_i[1]
+ wbs_adr_i[20] wbs_adr_i[21] wbs_adr_i[22] wbs_adr_i[23] wbs_adr_i[24] wbs_adr_i[25]
+ wbs_adr_i[26] wbs_adr_i[27] wbs_adr_i[28] wbs_adr_i[29] wbs_adr_i[2] wbs_adr_i[30]
+ wbs_adr_i[31] wbs_adr_i[3] wbs_adr_i[4] wbs_adr_i[5] wbs_adr_i[6] wbs_adr_i[7] wbs_adr_i[8]
+ wbs_adr_i[9] wbs_cyc_i wbs_dat_i[0] wbs_dat_i[10] wbs_dat_i[11] wbs_dat_i[12] wbs_dat_i[13]
+ wbs_dat_i[14] wbs_dat_i[15] wbs_dat_i[16] wbs_dat_i[17] wbs_dat_i[18] wbs_dat_i[19]
+ wbs_dat_i[1] wbs_dat_i[20] wbs_dat_i[21] wbs_dat_i[22] wbs_dat_i[23] wbs_dat_i[24]
+ wbs_dat_i[25] wbs_dat_i[26] wbs_dat_i[27] wbs_dat_i[28] wbs_dat_i[29] wbs_dat_i[2]
+ wbs_dat_i[30] wbs_dat_i[31] wbs_dat_i[3] wbs_dat_i[4] wbs_dat_i[5] wbs_dat_i[6]
+ wbs_dat_i[7] wbs_dat_i[8] wbs_dat_i[9] wbs_dat_o[0] wbs_dat_o[10] wbs_dat_o[11]
+ wbs_dat_o[12] wbs_dat_o[13] wbs_dat_o[14] wbs_dat_o[15] wbs_dat_o[16] wbs_dat_o[17]
+ wbs_dat_o[18] wbs_dat_o[19] wbs_dat_o[1] wbs_dat_o[20] wbs_dat_o[21] wbs_dat_o[22]
+ wbs_dat_o[23] wbs_dat_o[24] wbs_dat_o[25] wbs_dat_o[26] wbs_dat_o[27] wbs_dat_o[28]
+ wbs_dat_o[29] wbs_dat_o[2] wbs_dat_o[30] wbs_dat_o[31] wbs_dat_o[3] wbs_dat_o[4]
+ wbs_dat_o[5] wbs_dat_o[6] wbs_dat_o[7] wbs_dat_o[8] wbs_dat_o[9] wbs_sel_i[0] wbs_sel_i[1]
+ wbs_sel_i[2] wbs_sel_i[3] wbs_stb_i wbs_we_i VPWR VGND
XFILLER_79_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0985_ _0985_/D wbs_dat_o[8] _0984_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0419_ io_out[29] _0509_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_82_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0770_ _0789_/A _0770_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_5_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_37_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0968_ io_out[23] la_data_out[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0899_ _0899_/HI la_data_out[118] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_74_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_768 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_757 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_746 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_735 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_724 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_713 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_702 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_779 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_73_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0822_ _0822_/HI la_data_out[41] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0753_ _0753_/A _0753_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0684_ _0673_/X _0682_/X _0406_/A _0683_/Y _0685_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XFILLER_6_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_598 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_587 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_576 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_565 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_554 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_543 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_532 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_521 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_510 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1021_ _1021_/D io_out[12] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0805_ _0569_/A _0802_/X _0804_/X _1073_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0598_ wbs_dat_i[15] _0598_/B _0607_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0667_ _0445_/D _0574_/X _0679_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_39_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0736_ wbs_dat_o[26] _0736_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_69_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_395 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_384 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_340 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_351 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_362 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_373 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0452_ io_out[9] _0452_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XANTENNA_5 wbs_cyc_i VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0521_ _0520_/X _1071_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_3_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_66_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1004_ _0735_/X wbs_dat_o[27] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_62_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0719_ _0445_/B _0460_/Y la_data_in[34] _0460_/Y _1011_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_72_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_40_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0435_ _0435_/A _0564_/A _0435_/C _0553_/A _0507_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
X_0504_ _0500_/Y _0504_/B _0504_/C _0503_/Y _0504_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_54_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0984_ _0984_/D wbs_dat_o[7] _0984_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_55_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0418_ io_out[30] _0510_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_82_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0967_ io_out[22] la_data_out[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0898_ _0898_/HI la_data_out[117] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_74_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_769 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_758 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_747 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_736 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_725 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_714 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_703 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0821_ _0821_/HI la_data_out[40] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_80_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0752_ wbs_dat_o[19] _0752_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0683_ wbs_dat_i[0] _0673_/X _0683_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_6_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_500 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_599 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_588 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_577 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_566 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_555 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_544 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_533 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_522 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_511 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1020_ _1020_/D io_out[11] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_15_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_74_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0735_ _0732_/Y _0728_/X io_out[27] _0734_/X _0735_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0804_ io_out[31] _0511_/X _0513_/Y _0803_/Y _0804_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
X_0666_ _0658_/A _0663_/X _0666_/C _0666_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0597_ _0599_/A _0598_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_55_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_4_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_330 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_341 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_352 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_6 wbs_dat_i[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_396 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_385 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_374 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_363 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0451_ io_out[15] _0457_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0520_ _0516_/X _0518_/X io_oeb[36] _0519_/Y _0520_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XFILLER_6_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1003_ _1003_/D wbs_dat_o[26] _0984_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_19_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0718_ _0445_/A _0465_/C la_data_in[35] _0465_/C _1012_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_1_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0649_ _0436_/Y _0649_/B _0650_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_72_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_31_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0503_ la_oen[61] _0503_/B _0503_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0434_ io_out[22] _0553_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_54_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0983_ _0785_/X wbs_dat_o[6] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_12_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0417_ wbs_dat_i[30] _0417_/B _0515_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_82_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_32_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0966_ io_out[21] la_data_out[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0897_ _0897_/HI la_data_out[116] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_58_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_759 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_748 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_737 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_726 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_715 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_704 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_73_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0820_ _0820_/HI la_data_out[39] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0751_ _0750_/Y _0746_/X io_out[20] _0746_/X _0997_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_9_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0682_ _0445_/D _0574_/X _0679_/B _0682_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a21bo_4
XFILLER_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0949_ io_out[4] la_data_out[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_75_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_534 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_523 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_512 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_501 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_589 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_578 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_567 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_556 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_545 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_59_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0665_ _0649_/B _0664_/Y _0651_/Y _0666_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__a21o_4
X_0803_ io_out[31] _0511_/X _0803_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0734_ _0789_/A _0734_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_57_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0596_ wbs_ack_o _0412_/Y _0415_/C _0595_/Y _0599_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_0_0_counter.clk clkbuf_3_1_0_counter.clk/A _0984_/CLK VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_56_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_386 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_375 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_320 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_331 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_342 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_353 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_364 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XANTENNA_7 wbs_dat_i[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_397 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0450_ _0450_/A _0449_/Y _0457_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_39_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1002_ _0739_/X wbs_dat_o[25] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_66_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0717_ _0446_/B _0466_/Y la_data_in[36] _0466_/Y _1013_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0648_ _0446_/B _0664_/B _0649_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_72_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0579_ _0406_/A _0579_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_38_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_16_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0502_ la_oen[63] _0503_/B _0504_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_8_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0433_ io_out[23] _0435_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_54_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_26_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_49_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_3_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0982_ _0787_/X wbs_dat_o[5] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0416_ _0415_/X _0417_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_82_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0896_ _0896_/HI la_data_out[115] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0965_ io_out[20] la_data_out[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_70_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_727 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_716 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_705 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_749 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_738 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0681_ _0658_/A _0681_/B _0680_/Y _1043_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0750_ wbs_dat_o[20] _0750_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_49_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0948_ io_out[3] la_data_out[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0879_ _0879_/HI la_data_out[98] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_28_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_568 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_557 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_546 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_535 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_524 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_513 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_502 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_579 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0802_ wbs_dat_i[31] _0513_/A _0802_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0664_ _0446_/B _0664_/B _0664_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nand2_4
X_0733_ _0727_/A _0789_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_69_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_65_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0595_ wbs_sel_i[1] _0595_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_25_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_20_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_398 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_387 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_376 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_310 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_321 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_332 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_343 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_354 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_365 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_6_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_47_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_74_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1001_ _0742_/X wbs_dat_o[24] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
X_0716_ _0436_/Y _0470_/Y la_data_in[37] _0470_/Y _1014_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0578_ io_out[18] _0576_/Y io_out[19] _0428_/Y _0577_/X _0578_/X VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__a32o_4
X_0647_ _0574_/X _0446_/D _0664_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_82_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0432_ io_out[20] _0564_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0501_ la_oen[62] _0477_/B _0504_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_47_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0981_ _0790_/X wbs_dat_o[4] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_44_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0415_ wbs_ack_o _0412_/Y _0415_/C _0415_/D _0415_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_82_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_50_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_10_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_73_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_68_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0964_ io_out[19] la_data_out[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0895_ _0895_/HI la_data_out[114] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_67_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_82_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_739 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_728 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_717 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_706 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_64_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_34_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0680_ _0669_/Y _0679_/X _0673_/X _0680_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_10_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0947_ io_out[2] la_data_out[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0878_ _0878_/HI la_data_out[97] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_68_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_569 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_558 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_547 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_536 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_525 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_514 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_503 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0801_ la_data_in[64] la_oen[64] wb_clk_i _0800_/Y _0801_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__o22a_4
XFILLER_42_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0732_ wbs_dat_o[27] _0732_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0594_ _0641_/A _0591_/X _0594_/C _0594_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0663_ wbs_dat_i[4] _0655_/B _0663_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_65_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_71_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_300 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_399 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_388 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_377 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_311 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_322 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_333 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_344 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_355 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_366 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1000_ _1000_/D wbs_dat_o[23] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_13_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0715_ _0439_/Y _0471_/B la_data_in[38] _0471_/B _0715_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_30_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0577_ _0577_/A _0577_/B _0577_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0646_ wbs_dat_i[7] _0655_/B _0654_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_25_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0500_ la_oen[60] _0470_/B _0500_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0431_ io_out[21] _0435_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_22_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0629_ _0629_/A _1053_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_53_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0980_ _0792_/X wbs_dat_o[3] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_44_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0414_ wbs_sel_i[3] _0415_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_27_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_2_2_0_counter.clk clkbuf_2_2_0_counter.clk/A clkbuf_3_5_0_counter.clk/A VGND
+ VGND VPWR VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_26_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0894_ _0894_/HI la_data_out[113] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_32_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0963_ io_out[18] la_data_out[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_729 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_718 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_707 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_60_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0877_ _0877_/HI la_data_out[96] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0946_ io_out[1] la_data_out[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_559 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_548 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_537 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_526 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_515 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_504 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_46_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0800_ la_oen[64] _0800_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0731_ _0730_/Y _0728_/X io_out[28] _0728_/X _0731_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_42_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0662_ _0658_/A _0662_/B _0661_/X _1047_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0593_ _0586_/Y _0592_/X _0563_/X _0594_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0929_ io_oeb[36] io_oeb[20] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_71_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_301 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_312 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_323 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_334 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_389 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_378 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_345 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_356 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_367 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0645_ _0651_/A _0655_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0714_ _0440_/A _0471_/C la_data_in[39] _0471_/C _0714_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0576_ _0577_/B _0576_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_1059_ _0590_/Y io_out[17] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_53_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0430_ _0426_/Y _0427_/Y _0428_/Y _0577_/A _0430_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_35_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0628_ _0608_/X _0626_/X _0579_/X _0627_/Y _0629_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XFILLER_58_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0559_ wbs_dat_i[22] _0580_/B _0559_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_41_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0413_ wbs_we_i _0415_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_35_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_17_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0962_ io_out[17] la_data_out[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0893_ _0893_/HI la_data_out[112] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_719 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_708 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_63_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_20_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0876_ _0876_/HI la_data_out[95] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0945_ io_out[0] la_data_out[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_18_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_516 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_505 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_549 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_538 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_527 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0661_ _0650_/B _0660_/Y _0651_/Y _0661_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a21o_4
X_0730_ wbs_dat_o[28] _0730_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_6_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0592_ _0427_/Y _0586_/B _0592_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
XFILLER_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_80_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0859_ _0859_/HI la_data_out[78] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0928_ io_oeb[36] io_oeb[19] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_0_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_302 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_313 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_324 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_335 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_346 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_357 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_368 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_379 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0713_ _0453_/Y _0478_/A la_data_in[40] _0478_/A _1017_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0644_ wbs_ack_o _0412_/Y _0415_/C _0644_/D _0651_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
X_0575_ _0426_/Y _0427_/Y _0574_/X _0575_/D _0577_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_38_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1058_ _0594_/X io_out[16] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_25_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0627_ wbs_dat_i[11] _0598_/B _0627_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0558_ _0515_/A _0549_/X _0558_/C _1065_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
XFILLER_7_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0489_ _0485_/Y _0486_/Y _0489_/C _0488_/Y _0505_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_53_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0412_ _0503_/B _0412_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_4_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_35_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_58_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0961_ io_out[16] la_data_out[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0892_ _0892_/HI la_data_out[111] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_709 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_60_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0944_ io_oeb[36] io_oeb[35] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0875_ _0875_/HI la_data_out[94] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_539 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_528 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_517 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_506 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0660_ _0436_/Y _0649_/B _0660_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nand2_4
X_0591_ wbs_dat_i[16] _0570_/B _0591_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_40_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0927_ io_oeb[36] io_oeb[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0789_ _0789_/A _0789_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_29_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0858_ _0858_/HI la_data_out[77] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_29_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_303 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_314 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_325 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_336 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_347 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_358 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_369 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0712_ _0452_/Y _0477_/Y la_data_in[41] _0477_/Y _1018_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0574_ _0574_/A _0574_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0643_ wbs_sel_i[0] _0644_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_38_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1057_ _1057_/D io_out[15] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_53_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_16_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0626_ io_out[10] _0624_/Y io_out[11] _0454_/Y _0625_/X _0626_/X VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__a32o_4
X_0557_ io_out[23] _0553_/X _0555_/Y _0556_/Y _0558_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
X_0488_ la_oen[49] _0477_/B _0488_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_42_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_21_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_5_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0411_ _0466_/B _0503_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_5_0_counter.clk clkbuf_3_5_0_counter.clk/A _0996_/CLK VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__clkbuf_1
X_0609_ _0609_/A _0602_/X _0610_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_41_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_1_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0960_ io_out[15] la_data_out[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_40_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0891_ _0891_/HI la_data_out[110] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_63_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_37_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0874_ _0874_/HI la_data_out[93] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0943_ io_oeb[36] io_oeb[34] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_529 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_518 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_507 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0590_ _0590_/A _0590_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_41_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1073_ _1073_/D io_out[31] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_18_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0857_ _0857_/HI la_data_out[76] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0926_ io_oeb[36] io_oeb[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0788_ wbs_dat_o[4] _0788_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_29_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_304 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_315 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_326 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_337 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_348 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_359 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0711_ _0456_/D _0478_/B la_data_in[42] _0478_/B _0711_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0573_ _0641_/A _0570_/X _0573_/C _1062_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0642_ _0569_/A _0658_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1056_ _1056_/D io_out[14] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_40_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0909_ io_oeb[36] io_oeb[0] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_31_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_690 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0625_ _0456_/D _0623_/X _0625_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_7_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0487_ la_oen[51] _0491_/B _0489_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0556_ io_out[23] _0553_/X _0556_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_53_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1039_ _0691_/X io_out[30] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_38_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_29_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0410_ _0461_/A _0466_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_4_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_57_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0608_ _0638_/B _0608_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0539_ wbs_dat_i[25] _0417_/B _0539_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_81_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_53_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_78_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_17_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0890_ _0890_/HI la_data_out[109] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_32_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0942_ io_oeb[36] io_oeb[33] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0873_ _0873_/HI la_data_out[92] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_68_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_519 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_508 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_3_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_15_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1072_ _0515_/X io_out[30] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_1_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0856_ _0856_/HI la_data_out[75] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0787_ _0786_/Y _0782_/X io_out[5] _0782_/X _0787_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0925_ io_oeb[36] io_oeb[16] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_29_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_305 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_316 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_61_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_327 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_338 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_349 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0710_ _0454_/Y _0475_/Y la_data_in[43] _0475_/Y _1020_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0641_ _0641_/A _0641_/B _0641_/C _0641_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0572_ _0564_/Y _0571_/X _0563_/X _0573_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1055_ _0618_/X io_out[13] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_38_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0908_ _0908_/HI la_data_out[127] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0839_ _0839_/HI la_data_out[58] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_56_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_56_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_21_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_691 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_680 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0624_ _0623_/X _0624_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_7_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0486_ la_oen[50] _0486_/B _0486_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0555_ _0570_/B _0555_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_81_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1038_ _1038_/D io_out[29] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_38_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0607_ _0641_/A _0607_/B _0606_/X _1057_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0538_ io_out[25] _0537_/Y io_out[25] _0537_/Y _0538_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_81_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0469_ la_oen[39] _0491_/B _0471_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_26_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_78_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_67_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0941_ io_oeb[36] io_oeb[32] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_70_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0872_ _0872_/HI la_data_out[91] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_68_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_509 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_27_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1071_ _1071_/D io_out[29] _1037_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_1_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0924_ io_oeb[36] io_oeb[15] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0786_ wbs_dat_o[5] _0786_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0855_ _0855_/HI la_data_out[74] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_28_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_306 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_317 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_328 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_339 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_840 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0640_ _0633_/Y _0639_/X _0608_/X _0641_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__o21ai_4
X_0571_ _0564_/A _0551_/X _0571_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
XFILLER_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1054_ _1054_/D io_out[12] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0907_ _0907_/HI la_data_out[126] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0769_ wbs_dat_o[12] _0769_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_0_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0838_ _0838_/HI la_data_out[57] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_56_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_692 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_681 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_670 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0623_ _0452_/Y _0453_/Y _0574_/X _0446_/X _0623_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
X_0554_ _0554_/A _0570_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_7_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0485_ la_oen[48] _0486_/B _0485_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_26_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1037_ _1037_/D io_out[28] _1037_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0606_ _0600_/Y _0606_/B _0606_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_58_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0537_ _0422_/Y _0526_/C _0537_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_66_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0468_ _0461_/A _0491_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_14_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_39_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0940_ io_oeb[36] io_oeb[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0871_ _0871_/HI la_data_out[90] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_68_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_24_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1070_ _0525_/X io_out[28] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0854_ _0854_/HI la_data_out[73] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0923_ io_oeb[36] io_oeb[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0785_ _0784_/Y _0782_/X io_out[6] _0782_/X _0785_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
Xclkbuf_1_1_0_counter.clk clkbuf_0_counter.clk/X clkbuf_2_2_0_counter.clk/A VGND VGND
+ VPWR VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_56_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_307 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_318 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_329 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_841 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_830 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0570_ wbs_dat_i[20] _0570_/B _0570_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_76_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_80_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1053_ _1053_/D io_out[11] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_61_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0837_ _0837_/HI la_data_out[56] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0906_ _0906_/HI la_data_out[125] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0768_ _0767_/Y _0765_/X io_out[13] _0765_/X _0768_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0699_ _0553_/A _0491_/Y la_data_in[54] _0491_/Y _1031_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_71_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_46_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_693 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_682 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_671 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_660 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_7_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0484_ _0465_/X _0484_/B _0484_/C _0483_/X _0484_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
X_0553_ _0553_/A _0553_/B _0553_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0622_ _0641_/A _0619_/X _0622_/C _1054_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
XFILLER_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1036_ _0694_/X io_out[27] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_40_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_2_0_counter.clk clkbuf_3_3_0_counter.clk/A _1024_/CLK VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_25_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_12_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_43_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_490 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0467_ la_oen[38] _0486_/B _0471_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0605_ io_out[15] _0604_/Y _0458_/B _0633_/B _0606_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__o22a_4
X_0536_ _0618_/A _0535_/X _1068_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
XFILLER_37_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1019_ _0711_/X io_out[10] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_41_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0519_ wbs_dat_i[29] _0417_/B _0519_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_54_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_64_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0870_ _0870_/HI la_data_out[89] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_13_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0999_ _0747_/X wbs_dat_o[22] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_59_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0922_ io_oeb[36] io_oeb[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0853_ _0853_/HI la_data_out[72] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0784_ wbs_dat_o[6] _0784_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_68_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_308 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_319 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_19_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_820 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_842 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_831 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1052_ _0632_/X io_out[10] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_80_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0836_ _0836_/HI la_data_out[55] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0905_ _0905_/HI la_data_out[124] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0767_ wbs_dat_o[13] _0767_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0698_ _0435_/C _0492_/Y la_data_in[55] _0492_/Y _1032_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XPHY_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_12_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_661 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_650 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_694 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_683 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_672 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0621_ _0616_/B _0620_/X _0608_/X _0622_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_7_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0552_ _0435_/A _0564_/A _0551_/X _0553_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or3_4
X_0483_ _0483_/A _0483_/B _0483_/C _0482_/Y _0483_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1035_ _1035_/D io_out[26] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_38_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0819_ _0819_/HI la_data_out[38] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_72_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_491 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_480 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0604_ _0603_/X _0604_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0466_ la_oen[36] _0466_/B _0466_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0535_ _0513_/A _0528_/X _0534_/X wbs_dat_i[26] _0513_/Y _0535_/X VGND VGND VPWR
+ VPWR sky130_fd_sc_hd__a32o_4
XFILLER_81_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1018_ _1018_/D io_out[9] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_66_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_57_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0518_ io_out[29] _0517_/Y io_out[29] _0517_/Y _0518_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0449_ io_out[13] _0449_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_22_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_9_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_13_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0998_ _0998_/D wbs_dat_o[21] _0984_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_59_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0921_ io_oeb[36] io_oeb[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0852_ _0852_/HI la_data_out[71] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0783_ _0781_/Y _0777_/X io_out[7] _0782_/X _0984_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_5_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_309 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_10_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_843 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_832 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_821 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_810 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1051_ _0637_/Y io_out[9] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_65_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0904_ _0904_/HI la_data_out[123] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_21_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0766_ _0764_/Y _0765_/X io_out[14] _0765_/X _0766_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0697_ _0422_/Y _0495_/Y la_data_in[56] _0495_/Y _1033_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0835_ _0835_/HI la_data_out[54] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_29_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_24_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_79_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_695 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_684 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_673 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_662 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_651 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_640 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0620_ _0609_/A _0602_/X _0620_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
X_0551_ _0430_/X _0586_/B _0551_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_7_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0482_ la_oen[45] _0503_/B _0482_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1034_ _1034_/D io_out[25] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_38_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_21_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0818_ _0818_/HI la_data_out[37] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0749_ _0748_/Y _0746_/X io_out[21] _0746_/X _0998_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_69_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_492 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_481 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_470 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0603_ _0450_/A _0449_/Y _0609_/A _0602_/X _0603_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
X_0534_ io_out[26] _0527_/Y _0534_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_7_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0465_ _0465_/A _0460_/Y _0465_/C _0465_/D _0465_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_39_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1017_ _1017_/D io_out[8] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_26_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_63_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_8_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0517_ _0509_/B _0508_/X _0517_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0448_ io_out[14] _0450_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_54_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0997_ _0997_/D wbs_dat_o[20] _0984_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_74_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_42_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_27_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_2_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0920_ io_oeb[36] io_oeb[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0782_ _0727_/A _0782_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0851_ _0851_/HI la_data_out[70] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_5_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_844 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_833 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_822 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_811 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_800 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1050_ _0641_/X io_out[8] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_46_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0834_ _0834_/HI la_data_out[53] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_61_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0903_ _0903_/HI la_data_out[122] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_21_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0696_ _0421_/Y _0498_/Y la_data_in[57] _0498_/Y _1034_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0765_ _0753_/A _0765_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_56_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_28_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_696 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_685 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_674 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_663 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_652 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_641 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_630 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0550_ _0574_/A _0575_/D _0586_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_78_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0481_ la_oen[47] _0477_/B _0483_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_38_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_19_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1033_ _1033_/D io_out[24] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0817_ _0817_/HI la_data_out[36] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_21_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0679_ _0445_/C _0679_/B _0679_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
X_0748_ wbs_dat_o[21] _0748_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_57_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_493 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_482 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_471 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_460 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0602_ _0456_/X _0633_/B _0602_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0533_ _0569_/A _0618_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0464_ la_oen[33] _0470_/B _0465_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_3_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1016_ _0714_/X io_out[7] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_22_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_76_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_25_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_290 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_58_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0516_ _0513_/A _0516_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0447_ io_out[12] _0609_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_81_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_54_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_38_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0996_ _0754_/X wbs_dat_o[19] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_39_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0850_ _0850_/HI la_data_out[69] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_5_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0781_ wbs_dat_o[7] _0781_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_68_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0979_ _0979_/D wbs_dat_o[2] _1037_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_67_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_845 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_834 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_823 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_812 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_801 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_18_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0902_ _0902_/HI la_data_out[121] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0833_ _0833_/HI la_data_out[52] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0764_ wbs_dat_o[14] _0764_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0695_ _0425_/B _0499_/B la_data_in[58] _0499_/B _1035_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_37_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_52_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_620 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_697 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_686 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_675 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_664 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_653 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_642 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_631 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0480_ la_oen[46] _0470_/B _0483_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_7_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1032_ _1032_/D io_out[23] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_19_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0816_ _0816_/HI la_data_out[35] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0747_ _0745_/Y _0741_/X io_out[22] _0746_/X _0747_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0678_ wbs_dat_i[1] _0655_/B _0681_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_37_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_461 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_450 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0601_ _0574_/A _0446_/X _0633_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XPHY_494 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_483 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_472 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0463_ _0461_/A _0470_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0532_ _0531_/X _0532_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_81_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1015_ _0715_/X io_out[6] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_8_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_280 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_291 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_69_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0446_ _0436_/Y _0446_/B _0446_/C _0446_/D _0446_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
X_0515_ _0515_/A _0515_/B _0515_/C _0515_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
XFILLER_81_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0995_ _0756_/X wbs_dat_o[18] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_59_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0429_ io_out[18] _0577_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_39_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_27_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_82_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_54_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0780_ _0779_/Y _0777_/X io_out[8] _0777_/X _0985_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_51_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0978_ _0978_/D wbs_dat_o[1] _0984_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_59_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_802 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_74_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_70_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_835 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_824 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_813 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0901_ _0901_/HI la_data_out[120] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0832_ _0832_/HI la_data_out[51] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0763_ _0762_/Y _0758_/X io_out[15] _0758_/X _0992_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0694_ _0423_/Y _0497_/Y la_data_in[59] _0497_/Y _0694_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_56_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_62_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_643 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_632 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_621 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_610 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_698 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_687 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_676 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_665 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_654 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_7_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1031_ _1031_/D io_out[22] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0815_ _0815_/HI la_data_out[34] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0746_ _0789_/A _0746_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0677_ _0677_/A _0677_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_37_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_495 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_484 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_473 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_462 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_451 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_440 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0600_ _0638_/B _0600_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0531_ _0516_/X _0529_/X io_oeb[36] _0530_/Y _0531_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XFILLER_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0462_ la_oen[35] _0486_/B _0465_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1014_ _1014_/D io_out[5] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_54_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0729_ _0726_/Y _0728_/X io_out[29] _0728_/X _0729_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_72_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_270 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_281 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_292 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0514_ _0510_/Y _0511_/X _0513_/Y _0515_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__a21o_4
X_0445_ _0445_/A _0445_/B _0445_/C _0445_/D _0446_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_39_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0994_ _0759_/X wbs_dat_o[17] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0428_ io_out[19] _0428_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_67_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_7_0_counter.clk clkbuf_3_7_0_counter.clk/A _0991_/CLK VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_54_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_58_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0977_ _0799_/X wbs_dat_o[0] _1037_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_82_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_836 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_825 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_814 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_803 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_2_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0900_ _0900_/HI la_data_out[119] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_14_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0693_ _0509_/B _0500_/Y la_data_in[60] _0500_/Y _1037_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0831_ _0831_/HI la_data_out[50] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0762_ wbs_dat_o[15] _0762_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_69_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_677 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_666 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_655 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_644 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_633 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_622 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_611 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_600 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_46_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_30_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_699 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_688 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1030_ _1030_/D io_out[21] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0814_ _0814_/HI la_data_out[33] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0676_ _0673_/X _0674_/X _0406_/A _0675_/Y _0677_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
X_0745_ wbs_dat_o[22] _0745_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_72_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_37_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_496 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_485 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_474 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_463 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_452 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_441 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_430 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0530_ wbs_dat_i[27] _0417_/B _0530_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_11_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0461_ _0461_/A _0486_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_1013_ _1013_/D io_out[4] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0659_ wbs_dat_i[5] _0655_/B _0662_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0728_ _0753_/A _0728_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_69_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_16_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_260 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_271 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_282 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_293 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0444_ io_out[0] _0445_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0513_ _0513_/A _0513_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_79_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_81_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_80_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_36_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0993_ _0993_/D wbs_dat_o[16] _0984_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_1_0_counter.clk clkbuf_2_1_0_counter.clk/A clkbuf_3_3_0_counter.clk/A VGND
+ VGND VPWR VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_67_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0427_ io_out[16] _0427_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_39_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_45_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0976_ io_out[31] la_data_out[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_55_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_837 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_826 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_815 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_804 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_76_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0830_ _0830_/HI la_data_out[49] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_14_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0692_ _0509_/A _0503_/Y la_data_in[61] _0503_/Y _1038_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0761_ _0760_/Y _0758_/X io_out[16] _0758_/X _0993_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_24_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0959_ io_out[14] la_data_out[14] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_689 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_678 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_667 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_656 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_645 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_634 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_623 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_612 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_601 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0813_ _0813_/HI la_data_out[32] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0675_ wbs_dat_i[2] _0673_/X _0675_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0744_ _0743_/Y _0741_/X io_out[23] _0741_/X _1000_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_29_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_73_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_497 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_486 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_475 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_464 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_453 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_442 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_431 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_420 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0460_ la_oen[34] _0466_/B _0460_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_78_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1012_ _1012_/D io_out[3] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_19_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0727_ _0727_/A _0753_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_30_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0658_ _0658_/A _0658_/B _0657_/X _0658_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0589_ _0563_/X _0587_/X _0579_/X _0588_/Y _0590_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XFILLER_13_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_250 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_261 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_272 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_283 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_294 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0443_ io_out[1] _0445_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0512_ _0415_/X _0513_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_47_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_72_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0992_ _0992_/D wbs_dat_o[15] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0426_ io_out[17] _0426_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_27_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_40_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_73_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_68_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0975_ io_out[30] la_data_out[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0409_ _0408_/X _0461_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_55_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_838 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_827 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_816 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_805 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0760_ wbs_dat_o[16] _0760_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0691_ _0510_/A _0504_/B la_data_in[62] _0504_/B _0691_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_64_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0889_ _0889_/HI la_data_out[108] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0958_ io_out[13] la_data_out[13] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_20_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_602 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_679 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_668 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_657 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_646 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_635 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_624 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_613 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0812_ _0812_/HI io_out[37] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0743_ wbs_dat_o[23] _0743_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_69_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0674_ _0445_/B _0669_/A _0445_/B _0669_/A _0674_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_52_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_20_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_443 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_432 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_421 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_410 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_498 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_487 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_476 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_465 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_454 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1011_ _1011_/D io_out[2] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_19_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_19_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0726_ wbs_dat_o[29] _0726_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_30_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0588_ wbs_dat_i[17] _0580_/B _0588_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_69_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0657_ _0650_/X _0656_/Y _0651_/Y _0657_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a21o_4
XFILLER_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_4_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_240 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_251 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_262 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_273 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_284 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_295 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0511_ _0510_/A _0510_/B _0511_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_12_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0442_ io_out[2] _0445_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0709_ _0609_/A _0483_/A la_data_in[44] _0483_/A _1021_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_1_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_72_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_9_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_32_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0991_ _0766_/X wbs_dat_o[14] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_44_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0425_ _0423_/Y _0425_/B _0425_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_39_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_50_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_64_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0974_ io_out[29] la_data_out[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_82_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0408_ wbs_stb_i wbs_cyc_i _0408_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
XFILLER_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_839 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_828 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_817 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_806 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_51_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_23_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0690_ _0689_/Y _0504_/C la_data_in[63] _0504_/C _1040_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XPHY_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_49_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0888_ _0888_/HI la_data_out[107] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0957_ io_out[12] la_data_out[12] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_625 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_614 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_603 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_669 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_658 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_647 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_636 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_11_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0811_ _0811_/HI io_out[36] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_52_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0673_ _0651_/A _0673_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0742_ _0740_/Y _0741_/X io_out[24] _0741_/X _0742_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_6_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_477 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_466 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_455 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_444 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_433 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_422 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_411 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_400 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_499 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_488 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1010_ _1010_/D io_out[1] _1037_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_69_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0656_ _0439_/Y _0650_/B _0656_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nand2_4
X_0725_ _0724_/Y _1041_/D io_out[30] _1041_/D _1007_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_69_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0587_ io_out[17] _0586_/Y io_out[17] _0586_/Y _0587_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_80_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_230 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_241 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_252 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_263 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_274 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_285 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_296 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0510_ _0510_/A _0510_/B _0510_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nand2_4
XFILLER_79_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0441_ io_out[3] _0445_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_39_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0708_ _0449_/Y _0482_/Y la_data_in[45] _0482_/Y _1022_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0639_ _0453_/Y _0633_/B _0639_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
XFILLER_57_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_72_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_57_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_4_0_counter.clk clkbuf_3_5_0_counter.clk/A _1020_/CLK VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_5_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_28_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0990_ _0768_/X wbs_dat_o[13] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_60_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0424_ io_out[26] _0425_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_5_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0973_ io_out[28] la_data_out[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0407_ _0569_/A _0515_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_82_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_818 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_807 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_67_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_829 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0956_ io_out[11] la_data_out[11] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_60_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0887_ _0887_/HI la_data_out[106] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_46_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_62_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_659 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_648 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_637 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_626 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_615 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_604 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0810_ _0810_/HI io_out[35] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_14_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0672_ _0618_/A _0672_/B _0672_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
X_0741_ _0753_/A _0741_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0939_ io_oeb[36] io_oeb[30] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_20_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_43_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_489 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_478 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_467 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_456 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_445 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_434 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_423 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_412 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_401 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0655_ wbs_dat_i[6] _0655_/B _0658_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0586_ _0427_/Y _0586_/B _0586_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0724_ wbs_dat_o[30] _0724_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_69_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1069_ _0532_/Y io_out[27] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_43_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_220 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_231 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_242 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_253 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_264 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_275 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_286 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_297 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0440_ _0440_/A _0439_/Y _0446_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_3_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_22_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0707_ _0450_/A _0483_/B la_data_in[46] _0483_/B _0707_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0638_ wbs_dat_i[8] _0638_/B _0641_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_57_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0569_ _0569_/A _0641_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_57_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_53_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_70_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0423_ io_out[27] _0423_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_5_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0972_ io_out[27] la_data_out[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0406_ _0406_/A _0569_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_819 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_808 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_42_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_46_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_37_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0955_ io_out[10] la_data_out[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_60_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0886_ _0886_/HI la_data_out[105] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_20_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_28_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_649 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_638 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_627 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_616 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_605 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_78_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0740_ wbs_dat_o[24] _0740_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_52_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0671_ _0664_/B _0651_/A _0670_/X wbs_dat_i[3] _0651_/Y _0672_/B VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__a32o_4
XFILLER_6_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0938_ io_oeb[36] io_oeb[29] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0869_ _0869_/HI la_data_out[88] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_57_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_51_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_479 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_468 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_457 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_446 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_435 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_424 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_413 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_402 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0723_ _0722_/Y _1041_/D io_out[31] _1041_/D _0723_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_6_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_8_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0654_ _0658_/A _0654_/B _0654_/C _0654_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
X_0585_ _0618_/A _0585_/B _0585_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
XFILLER_65_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1068_ _1068_/D io_out[26] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_21_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_71_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_210 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_221 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_232 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_243 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_33_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_254 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_265 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_276 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_287 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_298 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_79_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0706_ _0457_/C _0483_/C la_data_in[47] _0483_/C _0706_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0568_ _0568_/A _1063_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0637_ _0636_/X _0637_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0499_ _0495_/Y _0499_/B _0497_/Y _0498_/Y _0505_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_38_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_5_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_17_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0422_ io_out[24] _0422_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_39_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_82_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_17_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0971_ io_out[26] la_data_out[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_32_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_0_counter.clk _0801_/X clkbuf_0_counter.clk/X VGND VGND VPWR VPWR sky130_fd_sc_hd__clkbuf_16
X_0405_ _0406_/A io_oeb[36] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XPHY_809 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_35_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_76_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_54_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0954_ io_out[9] la_data_out[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0885_ _0885_/HI la_data_out[104] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_36_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_639 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_628 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_617 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_606 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_11_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_14_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0670_ io_out[2] _0669_/Y io_out[3] _0670_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a21o_4
XFILLER_69_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_37_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0937_ io_oeb[36] io_oeb[28] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0868_ _0868_/HI la_data_out[87] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0799_ _0798_/Y _0794_/X io_out[0] _0794_/X _0799_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_57_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_43_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_425 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_414 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_403 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_469 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_458 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_447 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_436 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_34_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0722_ wbs_dat_o[31] _0722_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0653_ io_out[7] _0650_/X _0651_/Y _0652_/Y _0654_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XFILLER_8_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0584_ _0570_/B _0577_/X _0583_/X wbs_dat_i[18] _0555_/Y _0585_/B VGND VGND VPWR
+ VPWR sky130_fd_sc_hd__a32o_4
XFILLER_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1067_ _1067_/D io_out[25] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_80_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_68_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_211 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_222 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_233 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_244 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_255 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_266 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_277 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_33_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_288 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_299 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_66_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_15_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0636_ _0608_/X _0634_/X _0579_/X _0635_/Y _0636_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
X_0705_ _0427_/Y _0485_/Y la_data_in[48] _0485_/Y _1025_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0498_ la_oen[57] _0503_/B _0498_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0567_ _0563_/X _0565_/X io_oeb[36] _0566_/Y _0568_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XFILLER_38_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_48_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_29_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_4_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0421_ io_out[25] _0421_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_62_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0619_ wbs_dat_i[12] _0598_/B _0619_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_73_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_41_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_14_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_76_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0970_ io_out[25] la_data_out[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_40_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0404_ _0686_/C _0406_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_55_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_76_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_73_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_66_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0953_ io_out[8] la_data_out[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0884_ _0884_/HI la_data_out[103] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_13_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_607 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_629 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_618 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_51_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_46_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_19_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_1_0_0_counter.clk clkbuf_0_counter.clk/X clkbuf_2_1_0_counter.clk/A VGND VGND
+ VPWR VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_54_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0936_ io_oeb[36] io_oeb[27] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_33_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0798_ wbs_dat_o[0] _0798_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_0_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0867_ _0867_/HI la_data_out[86] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_51_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_459 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_448 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_437 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_426 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_415 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_404 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_59_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_47_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0583_ io_out[18] _0576_/Y _0583_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0652_ io_out[7] _0650_/X _0652_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0721_ _0445_/D _0465_/A la_data_in[32] _0465_/A _1009_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_69_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1066_ _0545_/X io_out[24] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
X_0919_ io_oeb[36] io_oeb[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_21_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_29_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_212 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_223 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_234 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_245 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_256 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_267 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_278 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_289 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_790 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_1_0_counter.clk clkbuf_3_1_0_counter.clk/A _1037_/CLK VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__clkbuf_1
X_0566_ wbs_dat_i[21] _0580_/B _0566_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0704_ _0426_/Y _0488_/Y la_data_in[49] _0488_/Y _1026_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0635_ wbs_dat_i[9] _0598_/B _0635_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0497_ la_oen[59] _0495_/B _0497_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_65_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1049_ _0654_/X io_out[7] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_53_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0420_ io_out[28] _0509_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_67_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_35_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0618_ _0618_/A _0618_/B _0618_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
XFILLER_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0549_ wbs_dat_i[23] _0580_/B _0549_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_58_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_39_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0403_ la_data_in[65] la_oen[65] wb_rst_i _0402_/Y _0686_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__o22a_4
XFILLER_82_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_67_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_54_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_41_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_64_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0952_ io_out[7] la_data_out[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0883_ _0883_/HI la_data_out[102] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XPHY_619 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_608 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_36_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_27_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0866_ _0866_/HI la_data_out[85] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_33_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0935_ io_oeb[36] io_oeb[26] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0797_ _0796_/Y _0794_/X io_out[1] _0794_/X _0978_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_28_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_449 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_438 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_427 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_416 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_405 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_42_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0720_ _0445_/C _0465_/D la_data_in[33] _0465_/D _1010_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_30_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0582_ _0581_/X _1061_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0651_ _0651_/A _0651_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_69_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_65_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_80_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1065_ _1065_/D io_out[23] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
X_0849_ _0849_/HI la_data_out[68] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0918_ io_oeb[36] io_oeb[9] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_29_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_213 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_224 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_235 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_246 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_257 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_268 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_279 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_62_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_791 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_780 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0703_ _0577_/A _0486_/Y la_data_in[50] _0486_/Y _1027_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_30_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0634_ io_out[9] _0633_/Y io_out[9] _0633_/Y _0634_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0565_ io_out[21] _0564_/Y io_out[21] _0564_/Y _0565_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0496_ la_oen[58] _0495_/B _0499_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_65_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_53_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1048_ _0658_/X io_out[6] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_0_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_21_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_71_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_71_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_12_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0617_ _0638_/B _0610_/X _0616_/X wbs_dat_i[13] _0600_/Y _0618_/B VGND VGND VPWR
+ VPWR sky130_fd_sc_hd__a32o_4
XFILLER_58_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0548_ _0554_/A _0580_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0479_ la_oen[44] _0470_/B _0483_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_81_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_38_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_17_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0402_ la_oen[65] _0402_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_82_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_14_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_1_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0951_ io_out[6] la_data_out[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0882_ _0882_/HI la_data_out[101] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_609 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_23_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_42_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_6_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_10_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0865_ _0865_/HI la_data_out[84] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0934_ io_oeb[36] io_oeb[25] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0796_ wbs_dat_o[1] _0796_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_73_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_439 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_428 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_417 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_406 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0581_ _0563_/X _0578_/X _0579_/X _0580_/Y _0581_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
X_0650_ _0439_/Y _0650_/B _0650_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_77_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1064_ _0562_/X io_out[22] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_38_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_21_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0917_ io_oeb[36] io_oeb[8] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0848_ _0848_/HI la_data_out[67] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0779_ wbs_dat_o[8] _0779_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_71_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_214 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_225 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_236 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_247 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_258 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_269 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_781 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_770 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_62_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_792 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0633_ _0453_/Y _0633_/B _0633_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0702_ _0428_/Y _0489_/C la_data_in[51] _0489_/C _0702_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_30_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0495_ la_oen[56] _0495_/B _0495_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0564_ _0564_/A _0551_/X _0564_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1047_ _1047_/D io_out[5] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_56_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_44_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_28_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_62_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_35_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0616_ io_out[13] _0616_/B _0616_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0478_ _0478_/A _0478_/B _0475_/Y _0477_/Y _0484_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_58_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0547_ wbs_ack_o _0412_/Y _0415_/C _0546_/Y _0554_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_38_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_55_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_26_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_41_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_77_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_1_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0950_ io_out[5] la_data_out[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0881_ _0881_/HI la_data_out[100] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xclkbuf_2_3_0_counter.clk clkbuf_2_2_0_counter.clk/A clkbuf_3_7_0_counter.clk/A VGND
+ VGND VPWR VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_51_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_46_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_36_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0864_ _0864_/HI la_data_out[83] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0933_ io_oeb[36] io_oeb[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0795_ _0793_/Y _0789_/X io_out[2] _0794_/X _0979_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_9_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_407 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_429 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_418 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_78_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0580_ wbs_dat_i[19] _0580_/B _0580_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_80_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1063_ _1063_/D io_out[21] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0916_ io_oeb[36] io_oeb[7] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_21_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0778_ _0776_/Y _0777_/X io_out[9] _0777_/X _0778_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0847_ _0847_/HI la_data_out[66] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_71_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_215 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_226 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_237 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_248 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_259 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_12_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_793 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_782 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_771 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_760 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0632_ _0618_/A _0632_/B _0632_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
X_0563_ _0570_/B _0563_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0701_ _0564_/A _0494_/A la_data_in[52] _0494_/A _1029_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_7_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0494_ _0494_/A _0491_/Y _0492_/Y _0493_/Y _0505_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_38_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1046_ _0666_/X io_out[4] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_53_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_26_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_8_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_60_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_67_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_590 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0615_ _0610_/B _0616_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0546_ wbs_sel_i[2] _0546_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0477_ la_oen[41] _0477_/B _0477_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_66_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1029_ _1029_/D io_out[20] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_30_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_49_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_1_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_72_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_35_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0529_ io_out[26] _0527_/Y io_out[27] _0423_/Y _0528_/X _0529_/X VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__a32o_4
XFILLER_54_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_81_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_41_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_1_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_82_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_45_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0880_ _0880_/HI la_data_out[99] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_48_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_59_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_36_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0932_ io_oeb[36] io_oeb[23] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_9_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0794_ _0727_/A _0794_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0863_ _0863_/HI la_data_out[82] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_5_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_419 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_408 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_19_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_42_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_8_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1062_ _1062_/D io_out[20] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_33_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0915_ io_oeb[36] io_oeb[6] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0777_ _0753_/A _0777_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0846_ _0846_/HI la_data_out[65] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_216 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_227 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_238 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_249 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_47_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_35_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_15_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_794 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_783 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_772 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_761 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_750 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0700_ _0435_/A _0493_/Y la_data_in[53] _0493_/Y _1030_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_30_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0631_ _0638_/B _0625_/X _0630_/X wbs_dat_i[10] _0600_/Y _0632_/B VGND VGND VPWR
+ VPWR sky130_fd_sc_hd__a32o_4
X_0562_ _0515_/A _0559_/X _0562_/C _0562_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
XFILLER_7_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0493_ la_oen[53] _0477_/B _0493_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1045_ _0672_/X io_out[3] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_0_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0829_ _0829_/HI la_data_out[48] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_56_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_591 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_580 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0614_ _0614_/A _1056_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0476_ _0466_/B _0477_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0545_ _0515_/A _0542_/X _0545_/C _0545_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
XFILLER_81_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_53_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_38_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1028_ _0702_/X io_out[19] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_14_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_55_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0528_ _0425_/B _0526_/X _0528_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_39_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0459_ la_oen[32] _0466_/B _0465_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_54_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_6_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_66_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_72_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_9_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_18_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0931_ io_oeb[36] io_oeb[22] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0862_ _0862_/HI la_data_out[81] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_9_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0793_ wbs_dat_o[2] _0793_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_68_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_409 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_3_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_15_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1061_ _1061_/D io_out[19] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_65_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0914_ io_oeb[36] io_oeb[5] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0845_ _0845_/HI la_data_out[64] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0776_ wbs_dat_o[9] _0776_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_68_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_217 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_228 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_239 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_24_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_795 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_784 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_773 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_762 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_751 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_740 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0492_ la_oen[55] _0495_/B _0492_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0630_ io_out[10] _0624_/Y _0630_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0561_ _0553_/X _0560_/Y _0555_/Y _0562_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__a21o_4
XFILLER_78_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_53_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1044_ _0677_/Y io_out[2] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_46_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_21_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0828_ _0828_/HI la_data_out[47] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0759_ _0757_/Y _0753_/X io_out[17] _0758_/X _0759_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_69_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_79_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_35_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_570 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_31_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0613_ _0608_/X _0611_/X _0579_/X _0612_/Y _0614_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XPHY_592 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_581 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0475_ la_oen[43] _0495_/B _0475_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0544_ _0537_/Y _0543_/X _0516_/X _0545_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_81_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_81_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1027_ _1027_/D io_out[18] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_53_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_34_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_30_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0458_ _0446_/X _0458_/B _0575_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0527_ _0526_/X _0527_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_39_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_25_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_25_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_17_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_3_6_0_counter.clk clkbuf_3_7_0_counter.clk/A _1005_/CLK VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_45_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_32_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_13_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_55_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_36_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_6_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_77_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0930_ io_oeb[36] io_oeb[21] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0792_ _0791_/Y _0789_/X io_out[3] _0789_/X _0792_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_9_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_0861_ _0861_/HI la_data_out[80] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_74_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_12_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1060_ _0585_/X io_out[18] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_2_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0913_ io_oeb[36] io_oeb[4] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0775_ _0774_/Y _0770_/X io_out[10] _0770_/X _0987_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0844_ _0844_/HI la_data_out[63] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XPHY_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_33_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_218 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_229 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_20_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_58_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_74_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_763 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_752 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_741 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_730 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_796 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_785 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_774 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0491_ la_oen[54] _0491_/B _0491_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0560_ _0553_/A _0553_/B _0560_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nand2_4
XFILLER_2_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_65_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1043_ _1043_/D io_out[1] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_0_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0827_ _0827_/HI la_data_out[46] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0758_ _0789_/A _0758_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_69_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0689_ io_out[31] _0689_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_28_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_12_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_593 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_582 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_571 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_560 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0612_ wbs_dat_i[14] _0598_/B _0612_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_66_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0474_ _0461_/A _0495_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0543_ _0422_/Y _0526_/C _0543_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
X_1026_ _1026_/D io_out[17] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_53_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_34_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_30_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_1_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_63_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_16_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_31_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_390 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_0 io_out[10] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0526_ _0421_/Y _0422_/Y _0526_/C _0526_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or3_4
X_0457_ _0609_/A _0457_/B _0457_/C _0456_/X _0458_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_54_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1009_ _1009_/D io_out[0] _1049_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_25_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
Xclkbuf_2_0_0_counter.clk clkbuf_2_1_0_counter.clk/A clkbuf_3_1_0_counter.clk/A VGND
+ VGND VPWR VPWR sky130_fd_sc_hd__clkbuf_1
XFILLER_82_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_72_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_66_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_13_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_36_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0509_ _0509_/A _0509_/B _0508_/X _0510_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or3_4
XFILLER_74_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_54_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_39_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_50_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_77_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_60_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_33_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0791_ wbs_dat_o[3] _0791_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_42_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0860_ _0860_/HI la_data_out[79] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_13_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_3_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_32_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0989_ _0989_/D wbs_dat_o[12] _1037_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_59_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_38_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_18_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0912_ io_oeb[36] io_oeb[3] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0843_ _0843_/HI la_data_out[62] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0774_ wbs_dat_o[10] _0774_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_68_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_219 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_17_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_58_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_786 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_775 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_764 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_753 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_742 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_70_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_731 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_720 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_30_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_797 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0490_ la_oen[52] _0486_/B _0494_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_53_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1042_ _0685_/Y io_out[0] _1037_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0757_ wbs_dat_o[17] _0757_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0688_ _0727_/A _1041_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0826_ _0826_/HI la_data_out[45] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_69_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_44_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_52_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_44_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_4_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_594 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_583 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_572 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_561 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_550 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_11_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0611_ _0450_/A _0610_/X _0604_/Y _0611_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a21o_4
XFILLER_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0542_ wbs_dat_i[24] _0513_/A _0542_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_78_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0473_ la_oen[42] _0491_/B _0478_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1025_ _1025_/D io_out[16] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_46_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0809_ _0809_/HI io_out[34] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_44_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_48_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XANTENNA_1 io_out[17] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_391 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_380 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_0456_ _0452_/Y _0453_/Y _0454_/Y _0456_/D _0456_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
X_0525_ _0515_/A _0522_/X _0525_/C _0525_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and3_4
XFILLER_26_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_1008_ _0723_/X wbs_dat_o[31] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_25_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_66_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_45_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_82_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_60_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_48_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_51_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0439_ io_out[6] _0439_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0508_ _0421_/Y _0422_/Y _0425_/X _0526_/C _0508_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_39_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_54_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_52_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_14_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_10_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_33_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_0790_ _0788_/Y _0789_/X io_out[4] _0789_/X _0790_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_13_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_32_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0988_ _0988_/D wbs_dat_o[11] _0984_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_47_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_47_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_27_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_2_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0842_ _0842_/HI la_data_out[61] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0911_ io_oeb[36] io_oeb[2] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_41_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_33_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_14_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0773_ _0772_/Y _0770_/X io_out[11] _0770_/X _0988_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_68_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_33_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_82_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_74_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_43_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_82_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_798 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_787 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_776 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_765 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_754 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_743 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_732 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_721 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_710 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_30_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_11_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_73_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1041_ _1041_/D wbs_ack_o _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_0_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0825_ _0825_/HI la_data_out[44] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0756_ _0755_/Y _0753_/X io_out[18] _0753_/X _0756_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0687_ _0687_/A _0727_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_37_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_60_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_75_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_47_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_43_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_43_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_35_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_595 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_584 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_573 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_562 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_551 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_540 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0472_ la_oen[40] _0491_/B _0478_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
X_0610_ _0449_/Y _0610_/B _0610_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0541_ _0540_/X _1067_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_78_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_66_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1024_ _0706_/X io_out[15] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_81_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_61_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0808_ _0808_/HI io_out[33] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0739_ _0738_/Y _0734_/X io_out[25] _0734_/X _0739_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_72_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_37_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_40_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_75_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_67_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_48_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_370 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_392 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_381 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_2 io_out[18] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0455_ io_out[10] _0456_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0524_ _0517_/Y _0523_/X _0516_/X _0525_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__o21ai_4
XFILLER_81_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_54_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1007_ _1007_/D wbs_dat_o[30] _1037_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_26_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_10_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_22_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_45_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_57_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_13_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_51_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_36_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0438_ io_out[7] _0440_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0507_ _0430_/X _0507_/B _0575_/D _0574_/A _0526_/C VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
XFILLER_27_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_50_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_10_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_45_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_41_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_3_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_76_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_32_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_8_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0987_ _0987_/D wbs_dat_o[10] _1024_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_59_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_42_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_27_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_23_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_61_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0910_ io_oeb[36] io_oeb[1] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
X_0841_ _0841_/HI la_data_out[60] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0772_ wbs_dat_o[11] _0772_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_14_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_49_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_24_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_59_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_711 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_700 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_799 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_788 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_777 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_766 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_755 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_744 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_733 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_722 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_23_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1040_ _1040_/D io_out[31] _1020_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_0_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_61_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0824_ _0824_/HI la_data_out[43] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0755_ wbs_dat_o[18] _0755_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0686_ wbs_ack_o _0412_/Y _0686_/C _0687_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__or3_4
XFILLER_29_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_56_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_37_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_60_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_52_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_70_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_55_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_552 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_541 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_530 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_43_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_28_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_596 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_585 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_574 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_563 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0471_ _0466_/Y _0471_/B _0471_/C _0470_/Y _0484_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
X_0540_ _0516_/X _0538_/X io_oeb[36] _0539_/Y _0540_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a211o_4
XFILLER_66_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1023_ _0707_/X io_out[14] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_61_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_34_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0807_ _0807_/HI io_out[32] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0738_ wbs_dat_o[25] _0738_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_69_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_69_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_57_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0669_ _0669_/A _0669_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_29_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_71_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_25_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_71_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_40_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_75_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_28_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_43_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_31_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_393 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_382 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_16_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_360 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_371 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_61_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XANTENNA_3 io_out[31] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_66_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_0454_ io_out[11] _0454_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0523_ _0509_/B _0508_/X _0523_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__and2_4
Xclkbuf_3_3_0_counter.clk clkbuf_3_3_0_counter.clk/A _1049_/CLK VGND VGND VPWR VPWR
+ sky130_fd_sc_hd__clkbuf_1
XFILLER_81_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1006_ _0729_/X wbs_dat_o[29] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_62_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_22_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_31_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_5_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_72_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0506_ _0484_/X _0505_/X _0574_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0437_ io_out[4] _0446_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_39_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_22_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_10_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_26_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0986_ _0778_/X wbs_dat_o[9] _0996_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_59_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_82_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_67_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_47_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_42_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_27_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_50_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_6_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_2_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_18_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0771_ _0769_/Y _0765_/X io_out[12] _0770_/X _0989_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0840_ _0840_/HI la_data_out[59] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
XFILLER_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_64_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_49_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_20_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_24_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0969_ io_out[24] la_data_out[24] VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_74_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_74_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_59_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_745 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_70_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_734 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_723 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_712 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_701 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_55_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_789 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_778 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_767 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_756 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_78_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_65_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_48_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_64_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_61_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_14_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_21_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0754_ _0752_/Y _0753_/X io_out[19] _0753_/X _0754_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
X_0823_ _0823_/HI la_data_out[42] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0685_ _0685_/A _0685_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_69_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_56_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_20_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_79_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_69_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_69_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_75_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_586 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_575 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_564 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_553 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_542 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_531 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_520 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_28_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_597 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_7_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_7_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_11_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0470_ la_oen[37] _0470_/B _0470_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__nor2_4
XFILLER_38_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_3_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_1022_ _1022_/D io_out[13] _0991_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_19_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0806_ _0806_/HI io_oeb[37] VGND VGND VPWR VPWR sky130_fd_sc_hd__conb_1
X_0668_ _0445_/C _0679_/B _0669_/A VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
X_0737_ _0736_/Y _0734_/X io_out[26] _0734_/X _1003_/D VGND VGND VPWR VPWR sky130_fd_sc_hd__a2bb2o_4
XFILLER_57_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0599_ _0599_/A _0638_/B VGND VGND VPWR VPWR sky130_fd_sc_hd__buf_2
XFILLER_37_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_80_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_71_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_4_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_75_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_63_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_28_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_77_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_394 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_383 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_350 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_361 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_372 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XANTENNA_4 la_data_in[46] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_0522_ wbs_dat_i[28] _0417_/B _0522_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or2_4
XFILLER_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_6_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0453_ io_out[8] _0453_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
XFILLER_39_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_81_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_81_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_62_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_1005_ _0731_/X wbs_dat_o[28] _1005_/CLK VGND VGND VPWR VPWR sky130_fd_sc_hd__dfxtp_4
XFILLER_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_19_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_41_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_66_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_57_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_45_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_17_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_40_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_25_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_9_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_15_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_21_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_31_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_5_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_63_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_0_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_56_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_44_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XFILLER_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
XPHY_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_8_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_12
X_0436_ io_out[5] _0436_/Y VGND VGND VPWR VPWR sky130_fd_sc_hd__inv_2
X_0505_ _0505_/A _0505_/B _0505_/C _0504_/X _0505_/X VGND VGND VPWR VPWR sky130_fd_sc_hd__or4_4
.ends
